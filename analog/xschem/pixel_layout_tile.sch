v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
N -230 500 -150 500 {lab=VDD}
N -230 520 -150 520 {lab=GndA}
N -230 540 -150 540 {lab=GndD}
N -230 580 -150 580 {lab=DiffBn}
N -230 600 -150 600 {lab=RefrBp}
N -230 620 -150 620 {lab=PrSFBp}
N -230 640 -150 640 {lab=OffBn}
N -230 660 -150 660 {lab=PrBp}
N -230 680 -150 680 {lab=OnBn}
N -230 1300 -150 1300 {lab=rowReadON[2]}
N -230 1320 -150 1320 {lab=rowReadOFF[2]}
N -230 1340 -150 1340 {lab=rowReadON[3]}
N -230 1360 -150 1360 {lab=rowReadOFF[3]}
N -230 1820 -150 1820 {lab=rowReadON[4]}
N -230 1840 -150 1840 {lab=rowReadOFF[4]}
N -230 1860 -150 1860 {lab=rowReadON[5]}
N -230 1880 -150 1880 {lab=rowReadOFF[5]}
N -230 2340 -150 2340 {lab=rowReadON[6]}
N -230 2360 -150 2360 {lab=rowReadOFF[6]}
N -230 2380 -150 2380 {lab=rowReadON[7]}
N -230 2400 -150 2400 {lab=rowReadOFF[7]}
N -230 2860 -150 2860 {lab=rowReadON[8]}
N -230 2880 -150 2880 {lab=rowReadOFF[8]}
N -230 2900 -150 2900 {lab=rowReadON[9]}
N -230 2920 -150 2920 {lab=rowReadOFF[9]}
N -230 3380 -150 3380 {lab=rowReadON[10]}
N -230 3400 -150 3400 {lab=rowReadOFF[10]}
N -230 3420 -150 3420 {lab=rowReadON[11]}
N -230 3440 -150 3440 {lab=rowReadOFF[11]}
N -230 3900 -150 3900 {lab=rowReadON[12]}
N -230 3920 -150 3920 {lab=rowReadOFF[12]}
N -230 3940 -150 3940 {lab=rowReadON[13]}
N -230 3960 -150 3960 {lab=rowReadOFF[13]}
N -230 4420 -150 4420 {lab=rowReadON[14]}
N -230 4440 -150 4440 {lab=rowReadOFF[14]}
N -230 4460 -150 4460 {lab=rowReadON[15]}
N -230 4480 -150 4480 {lab=rowReadOFF[15]}
N -230 4940 -150 4940 {lab=rowReadON[16]}
N -230 4960 -150 4960 {lab=rowReadOFF[16]}
N -230 4980 -150 4980 {lab=rowReadON[17]}
N -230 5000 -150 5000 {lab=rowReadOFF[17]}
N -230 5460 -150 5460 {lab=rowReadON[18]}
N -230 5480 -150 5480 {lab=rowReadOFF[18]}
N -230 5500 -150 5500 {lab=rowReadON[19]}
N -230 5520 -150 5520 {lab=rowReadOFF[19]}
N -230 5980 -150 5980 {lab=rowReadON[20]}
N -230 6000 -150 6000 {lab=rowReadOFF[20]}
N -230 6020 -150 6020 {lab=rowReadON[21]}
N -230 6040 -150 6040 {lab=rowReadOFF[21]}
N -230 6500 -150 6500 {lab=rowReadON[22]}
N -230 6520 -150 6520 {lab=rowReadOFF[22]}
N -230 6540 -150 6540 {lab=rowReadON[23]}
N -230 6560 -150 6560 {lab=rowReadOFF[23]}
N -230 7020 -150 7020 {lab=rowReadON[24]}
N -230 7040 -150 7040 {lab=rowReadOFF[24]}
N -230 7060 -150 7060 {lab=rowReadON[25]}
N -230 7080 -150 7080 {lab=rowReadOFF[25]}
N -230 7540 -150 7540 {lab=rowReadON[26]}
N -230 7560 -150 7560 {lab=rowReadOFF[26]}
N -230 7580 -150 7580 {lab=rowReadON[27]}
N -230 7600 -150 7600 {lab=rowReadOFF[27]}
N -230 8060 -150 8060 {lab=rowReadON[28]}
N -230 8080 -150 8080 {lab=rowReadOFF[28]}
N -230 8100 -150 8100 {lab=rowReadON[29]}
N -230 8120 -150 8120 {lab=rowReadOFF[29]}
N -230 8580 -150 8580 {lab=rowReadON[30]}
N -230 8600 -150 8600 {lab=rowReadOFF[30]}
N -230 8620 -150 8620 {lab=rowReadON[31]}
N -230 8640 -150 8640 {lab=rowReadOFF[31]}
N -230 9100 -150 9100 {lab=rowReadON[32]}
N -230 9120 -150 9120 {lab=rowReadOFF[32]}
N -230 9140 -150 9140 {lab=rowReadON[33]}
N -230 9160 -150 9160 {lab=rowReadOFF[33]}
N -230 9620 -150 9620 {lab=rowReadON[34]}
N -230 9640 -150 9640 {lab=rowReadOFF[34]}
N -230 9660 -150 9660 {lab=rowReadON[35]}
N -230 9680 -150 9680 {lab=rowReadOFF[35]}
N -230 10140 -150 10140 {lab=rowReadON[36]}
N -230 10160 -150 10160 {lab=rowReadOFF[36]}
N -230 10180 -150 10180 {lab=rowReadON[37]}
N -230 10200 -150 10200 {lab=rowReadOFF[37]}
N -230 10660 -150 10660 {lab=rowReadON[38]}
N -230 10680 -150 10680 {lab=rowReadOFF[38]}
N -230 10700 -150 10700 {lab=rowReadON[39]}
N -230 10720 -150 10720 {lab=rowReadOFF[39]}
N -230 11180 -150 11180 {lab=rowReadON[40]}
N -230 11200 -150 11200 {lab=rowReadOFF[40]}
N -230 11220 -150 11220 {lab=rowReadON[41]}
N -230 11240 -150 11240 {lab=rowReadOFF[41]}
N -230 11700 -150 11700 {lab=rowReadON[42]}
N -230 11720 -150 11720 {lab=rowReadOFF[42]}
N -230 11740 -150 11740 {lab=rowReadON[43]}
N -230 11760 -150 11760 {lab=rowReadOFF[43]}
N -230 12220 -150 12220 {lab=rowReadON[44]}
N -230 12240 -150 12240 {lab=rowReadOFF[44]}
N -230 12260 -150 12260 {lab=rowReadON[45]}
N -230 12280 -150 12280 {lab=rowReadOFF[45]}
N -230 12740 -150 12740 {lab=rowReadON[46]}
N -230 12760 -150 12760 {lab=rowReadOFF[46]}
N -230 12780 -150 12780 {lab=rowReadON[47]}
N -230 12800 -150 12800 {lab=rowReadOFF[47]}
N -230 13260 -150 13260 {lab=rowReadON[48]}
N -230 13280 -150 13280 {lab=rowReadOFF[48]}
N -230 13300 -150 13300 {lab=rowReadON[49]}
N -230 13320 -150 13320 {lab=rowReadOFF[49]}
N -230 13780 -150 13780 {lab=rowReadON[50]}
N -230 13800 -150 13800 {lab=rowReadOFF[50]}
N -230 13820 -150 13820 {lab=rowReadON[51]}
N -230 13840 -150 13840 {lab=rowReadOFF[51]}
N -230 14300 -150 14300 {lab=rowReadON[52]}
N -230 14320 -150 14320 {lab=rowReadOFF[52]}
N -230 14340 -150 14340 {lab=rowReadON[53]}
N -230 14360 -150 14360 {lab=rowReadOFF[53]}
N -230 14820 -150 14820 {lab=rowReadON[54]}
N -230 14840 -150 14840 {lab=rowReadOFF[54]}
N -230 14860 -150 14860 {lab=rowReadON[55]}
N -230 14880 -150 14880 {lab=rowReadOFF[55]}
N -230 15340 -150 15340 {lab=rowReadON[56]}
N -230 15360 -150 15360 {lab=rowReadOFF[56]}
N -230 15380 -150 15380 {lab=rowReadON[57]}
N -230 15400 -150 15400 {lab=rowReadOFF[57]}
N -230 15860 -150 15860 {lab=rowReadON[58]}
N -230 15880 -150 15880 {lab=rowReadOFF[58]}
N -230 15900 -150 15900 {lab=rowReadON[59]}
N -230 15920 -150 15920 {lab=rowReadOFF[59]}
N -230 16380 -150 16380 {lab=rowReadON[60]}
N -230 16400 -150 16400 {lab=rowReadOFF[60]}
N -230 16420 -150 16420 {lab=rowReadON[61]}
N -230 16440 -150 16440 {lab=rowReadOFF[61]}
N -230 16900 -150 16900 {lab=rowReadON[62]}
N -230 16920 -150 16920 {lab=rowReadOFF[62]}
N -230 16940 -150 16940 {lab=rowReadON[63]}
N -230 16960 -150 16960 {lab=rowReadOFF[63]}
N -230 270 -150 270 {lab=GndA}
N -230 250 -150 250 {lab=VDD}
N -230 230 -150 230 {lab=NCHARGE}
N -230 210 -150 210 {lab=VTHRESH}
N -230 190 -150 190 {lab=nDETECT}
N -230 170 -150 170 {lab=DETECT}
N -110 -30 -110 50 {lab=pixRst[0]}
N 130 -30 130 50 {lab=pixRst[1]}
N -50 -30 -50 50 {lab=voutn[0]}
N 70 -30 70 50 {lab=voutn[1]}
N 230 -30 230 50 {lab=pixRst[2]}
N 470 -30 470 50 {lab=pixRst[3]}
N 290 -30 290 50 {lab=voutn[2]}
N 410 -30 410 50 {lab=voutn[3]}
N 570 -30 570 50 {lab=pixRst[4]}
N 810 -30 810 50 {lab=pixRst[5]}
N 630 -30 630 50 {lab=voutn[4]}
N 750 -30 750 50 {lab=voutn[5]}
N 910 -30 910 50 {lab=pixRst[6]}
N 1150 -30 1150 50 {lab=pixRst[7]}
N 970 -30 970 50 {lab=voutn[6]}
N 1090 -30 1090 50 {lab=voutn[7]}
N 1250 -30 1250 50 {lab=pixRst[8]}
N 1490 -30 1490 50 {lab=pixRst[9]}
N 1310 -30 1310 50 {lab=voutn[8]}
N 1430 -30 1430 50 {lab=voutn[9]}
N 1590 -30 1590 50 {lab=pixRst[10]}
N 1830 -30 1830 50 {lab=pixRst[11]}
N 1650 -30 1650 50 {lab=voutn[10]}
N 1770 -30 1770 50 {lab=voutn[11]}
N 1930 -30 1930 50 {lab=pixRst[12]}
N 2170 -30 2170 50 {lab=pixRst[13]}
N 1990 -30 1990 50 {lab=voutn[12]}
N 2110 -30 2110 50 {lab=voutn[13]}
N 2270 -30 2270 50 {lab=pixRst[14]}
N 2510 -30 2510 50 {lab=pixRst[15]}
N 2330 -30 2330 50 {lab=voutn[14]}
N 2450 -30 2450 50 {lab=voutn[15]}
N 2610 -30 2610 50 {lab=pixRst[16]}
N 2850 -30 2850 50 {lab=pixRst[17]}
N 2670 -30 2670 50 {lab=voutn[16]}
N 2790 -30 2790 50 {lab=voutn[17]}
N 2950 -30 2950 50 {lab=pixRst[18]}
N 3190 -30 3190 50 {lab=pixRst[19]}
N 3010 -30 3010 50 {lab=voutn[18]}
N 3130 -30 3130 50 {lab=voutn[19]}
N 3290 -30 3290 50 {lab=pixRst[20]}
N 3530 -30 3530 50 {lab=pixRst[21]}
N 3350 -30 3350 50 {lab=voutn[20]}
N 3470 -30 3470 50 {lab=voutn[21]}
N 3630 -30 3630 50 {lab=pixRst[22]}
N 3870 -30 3870 50 {lab=pixRst[23]}
N 3690 -30 3690 50 {lab=voutn[22]}
N 3810 -30 3810 50 {lab=voutn[23]}
N 3970 -30 3970 50 {lab=pixRst[24]}
N 4210 -30 4210 50 {lab=pixRst[25]}
N 4030 -30 4030 50 {lab=voutn[24]}
N 4150 -30 4150 50 {lab=voutn[25]}
N 4310 -30 4310 50 {lab=pixRst[26]}
N 4550 -30 4550 50 {lab=pixRst[27]}
N 4370 -30 4370 50 {lab=voutn[26]}
N 4490 -30 4490 50 {lab=voutn[27]}
N 4650 -30 4650 50 {lab=pixRst[28]}
N 4890 -30 4890 50 {lab=pixRst[29]}
N 4710 -30 4710 50 {lab=voutn[28]}
N 4830 -30 4830 50 {lab=voutn[29]}
N 4990 -30 4990 50 {lab=pixRst[30]}
N 5230 -30 5230 50 {lab=pixRst[31]}
N 5050 -30 5050 50 {lab=voutn[30]}
N 5170 -30 5170 50 {lab=voutn[31]}
N 5330 -30 5330 50 {lab=pixRst[32]}
N 5570 -30 5570 50 {lab=pixRst[33]}
N 5390 -30 5390 50 {lab=voutn[32]}
N 5510 -30 5510 50 {lab=voutn[33]}
N 5670 -30 5670 50 {lab=pixRst[34]}
N 5910 -30 5910 50 {lab=pixRst[35]}
N 5730 -30 5730 50 {lab=voutn[34]}
N 5850 -30 5850 50 {lab=voutn[35]}
N 6010 -30 6010 50 {lab=pixRst[36]}
N 6250 -30 6250 50 {lab=pixRst[37]}
N 6070 -30 6070 50 {lab=voutn[36]}
N 6190 -30 6190 50 {lab=voutn[37]}
N 6350 -30 6350 50 {lab=pixRst[38]}
N 6590 -30 6590 50 {lab=pixRst[39]}
N 6410 -30 6410 50 {lab=voutn[38]}
N 6530 -30 6530 50 {lab=voutn[39]}
N 6690 -30 6690 50 {lab=pixRst[40]}
N 6930 -30 6930 50 {lab=pixRst[41]}
N 6750 -30 6750 50 {lab=voutn[40]}
N 6870 -30 6870 50 {lab=voutn[41]}
N 7030 -30 7030 50 {lab=pixRst[42]}
N 7270 -30 7270 50 {lab=pixRst[43]}
N 7090 -30 7090 50 {lab=voutn[42]}
N 7210 -30 7210 50 {lab=voutn[43]}
N 7370 -30 7370 50 {lab=pixRst[44]}
N 7610 -30 7610 50 {lab=pixRst[45]}
N 7430 -30 7430 50 {lab=voutn[44]}
N 7550 -30 7550 50 {lab=voutn[45]}
N 7710 -30 7710 50 {lab=pixRst[46]}
N 7950 -30 7950 50 {lab=pixRst[47]}
N 7770 -30 7770 50 {lab=voutn[46]}
N 7890 -30 7890 50 {lab=voutn[47]}
N 8050 -30 8050 50 {lab=pixRst[48]}
N 8290 -30 8290 50 {lab=pixRst[49]}
N 8110 -30 8110 50 {lab=voutn[48]}
N 8230 -30 8230 50 {lab=voutn[49]}
N 8390 -30 8390 50 {lab=pixRst[50]}
N 8630 -30 8630 50 {lab=pixRst[51]}
N 8450 -30 8450 50 {lab=voutn[50]}
N 8570 -30 8570 50 {lab=voutn[51]}
N 8730 -30 8730 50 {lab=pixRst[52]}
N 8970 -30 8970 50 {lab=pixRst[53]}
N 8790 -30 8790 50 {lab=voutn[52]}
N 8910 -30 8910 50 {lab=voutn[53]}
N 9070 -30 9070 50 {lab=pixRst[54]}
N 9310 -30 9310 50 {lab=pixRst[55]}
N 9130 -30 9130 50 {lab=voutn[54]}
N 9250 -30 9250 50 {lab=voutn[55]}
N 9410 -30 9410 50 {lab=pixRst[56]}
N 9650 -30 9650 50 {lab=pixRst[57]}
N 9470 -30 9470 50 {lab=voutn[56]}
N 9590 -30 9590 50 {lab=voutn[57]}
N 9750 -30 9750 50 {lab=pixRst[58]}
N 9990 -30 9990 50 {lab=pixRst[59]}
N 9810 -30 9810 50 {lab=voutn[58]}
N 9930 -30 9930 50 {lab=voutn[59]}
N 10090 -30 10090 50 {lab=pixRst[60]}
N 10330 -30 10330 50 {lab=pixRst[61]}
N 10150 -30 10150 50 {lab=voutn[60]}
N 10270 -30 10270 50 {lab=voutn[61]}
N 10430 -30 10430 50 {lab=pixRst[62]}
N 10670 -30 10670 50 {lab=pixRst[63]}
N 10490 -30 10490 50 {lab=voutn[62]}
N 10610 -30 10610 50 {lab=voutn[63]}
N -230 780 -150 780 {lab=rowReadON[0]}
N -230 800 -150 800 {lab=rowReadOFF[0]}
N -230 820 -150 820 {lab=rowReadON[1]}
N -230 840 -150 840 {lab=rowReadOFF[1]}
C {openDVS_pixel2x2_top.sym} 0 530 0 0 {name=x0}
C {openDVS_pixel2x2_top.sym} 340 530 0 0 {name=x1}
C {openDVS_pixel2x2_top.sym} 680 530 0 0 {name=x2}
C {openDVS_pixel2x2_top.sym} 1020 530 0 0 {name=x3}
C {openDVS_pixel2x2_top.sym} 1360 530 0 0 {name=x4}
C {openDVS_pixel2x2_top.sym} 1700 530 0 0 {name=x5}
C {openDVS_pixel2x2_top.sym} 2040 530 0 0 {name=x6}
C {openDVS_pixel2x2_top.sym} 2380 530 0 0 {name=x7}
C {openDVS_pixel2x2_top.sym} 2720 530 0 0 {name=x8}
C {openDVS_pixel2x2_top.sym} 3060 530 0 0 {name=x9}
C {openDVS_pixel2x2_top.sym} 3400 530 0 0 {name=x10}
C {openDVS_pixel2x2_top.sym} 3740 530 0 0 {name=x11}
C {openDVS_pixel2x2_top.sym} 4080 530 0 0 {name=x12}
C {openDVS_pixel2x2_top.sym} 4420 530 0 0 {name=x13}
C {openDVS_pixel2x2_top.sym} 4760 530 0 0 {name=x14}
C {openDVS_pixel2x2_top.sym} 5100 530 0 0 {name=x15}
C {openDVS_pixel2x2_top.sym} 5440 530 0 0 {name=x16}
C {openDVS_pixel2x2_top.sym} 5780 530 0 0 {name=x17}
C {openDVS_pixel2x2_top.sym} 6120 530 0 0 {name=x18}
C {openDVS_pixel2x2_top.sym} 6460 530 0 0 {name=x19}
C {openDVS_pixel2x2_top.sym} 6800 530 0 0 {name=x20}
C {openDVS_pixel2x2_top.sym} 7140 530 0 0 {name=x21}
C {openDVS_pixel2x2_top.sym} 7480 530 0 0 {name=x22}
C {openDVS_pixel2x2_top.sym} 7820 530 0 0 {name=x23}
C {openDVS_pixel2x2_top.sym} 8160 530 0 0 {name=x24}
C {openDVS_pixel2x2_top.sym} 8500 530 0 0 {name=x25}
C {openDVS_pixel2x2_top.sym} 8840 530 0 0 {name=x26}
C {openDVS_pixel2x2_top.sym} 9180 530 0 0 {name=x27}
C {openDVS_pixel2x2_top.sym} 9520 530 0 0 {name=x28}
C {openDVS_pixel2x2_top.sym} 9860 530 0 0 {name=x29}
C {openDVS_pixel2x2_top.sym} 10200 530 0 0 {name=x30}
C {openDVS_pixel2x2_top.sym} 10540 530 0 0 {name=x31}
C {openDVS_pixel2x2_top.sym} 0 1050 0 0 {name=x32}
C {openDVS_pixel2x2_top.sym} 340 1050 0 0 {name=x33}
C {openDVS_pixel2x2_top.sym} 680 1050 0 0 {name=x34}
C {openDVS_pixel2x2_top.sym} 1020 1050 0 0 {name=x35}
C {openDVS_pixel2x2_top.sym} 1360 1050 0 0 {name=x36}
C {openDVS_pixel2x2_top.sym} 1700 1050 0 0 {name=x37}
C {openDVS_pixel2x2_top.sym} 2040 1050 0 0 {name=x38}
C {openDVS_pixel2x2_top.sym} 2380 1050 0 0 {name=x39}
C {openDVS_pixel2x2_top.sym} 2720 1050 0 0 {name=x40}
C {openDVS_pixel2x2_top.sym} 3060 1050 0 0 {name=x41}
C {openDVS_pixel2x2_top.sym} 3400 1050 0 0 {name=x42}
C {openDVS_pixel2x2_top.sym} 3740 1050 0 0 {name=x43}
C {openDVS_pixel2x2_top.sym} 4080 1050 0 0 {name=x44}
C {openDVS_pixel2x2_top.sym} 4420 1050 0 0 {name=x45}
C {openDVS_pixel2x2_top.sym} 4760 1050 0 0 {name=x46}
C {openDVS_pixel2x2_top.sym} 5100 1050 0 0 {name=x47}
C {openDVS_pixel2x2_top.sym} 5440 1050 0 0 {name=x48}
C {openDVS_pixel2x2_top.sym} 5780 1050 0 0 {name=x49}
C {openDVS_pixel2x2_top.sym} 6120 1050 0 0 {name=x50}
C {openDVS_pixel2x2_top.sym} 6460 1050 0 0 {name=x51}
C {openDVS_pixel2x2_top.sym} 6800 1050 0 0 {name=x52}
C {openDVS_pixel2x2_top.sym} 7140 1050 0 0 {name=x53}
C {openDVS_pixel2x2_top.sym} 7480 1050 0 0 {name=x54}
C {openDVS_pixel2x2_top.sym} 7820 1050 0 0 {name=x55}
C {openDVS_pixel2x2_top.sym} 8160 1050 0 0 {name=x56}
C {openDVS_pixel2x2_top.sym} 8500 1050 0 0 {name=x57}
C {openDVS_pixel2x2_top.sym} 8840 1050 0 0 {name=x58}
C {openDVS_pixel2x2_top.sym} 9180 1050 0 0 {name=x59}
C {openDVS_pixel2x2_top.sym} 9520 1050 0 0 {name=x60}
C {openDVS_pixel2x2_top.sym} 9860 1050 0 0 {name=x61}
C {openDVS_pixel2x2_top.sym} 10200 1050 0 0 {name=x62}
C {openDVS_pixel2x2_top.sym} 10540 1050 0 0 {name=x63}
C {openDVS_pixel2x2_top.sym} 0 1570 0 0 {name=x64}
C {openDVS_pixel2x2_top.sym} 340 1570 0 0 {name=x65}
C {openDVS_pixel2x2_top.sym} 680 1570 0 0 {name=x66}
C {openDVS_pixel2x2_top.sym} 1020 1570 0 0 {name=x67}
C {openDVS_pixel2x2_top.sym} 1360 1570 0 0 {name=x68}
C {openDVS_pixel2x2_top.sym} 1700 1570 0 0 {name=x69}
C {openDVS_pixel2x2_top.sym} 2040 1570 0 0 {name=x70}
C {openDVS_pixel2x2_top.sym} 2380 1570 0 0 {name=x71}
C {openDVS_pixel2x2_top.sym} 2720 1570 0 0 {name=x72}
C {openDVS_pixel2x2_top.sym} 3060 1570 0 0 {name=x73}
C {openDVS_pixel2x2_top.sym} 3400 1570 0 0 {name=x74}
C {openDVS_pixel2x2_top.sym} 3740 1570 0 0 {name=x75}
C {openDVS_pixel2x2_top.sym} 4080 1570 0 0 {name=x76}
C {openDVS_pixel2x2_top.sym} 4420 1570 0 0 {name=x77}
C {openDVS_pixel2x2_top.sym} 4760 1570 0 0 {name=x78}
C {openDVS_pixel2x2_top.sym} 5100 1570 0 0 {name=x79}
C {openDVS_pixel2x2_top.sym} 5440 1570 0 0 {name=x80}
C {openDVS_pixel2x2_top.sym} 5780 1570 0 0 {name=x81}
C {openDVS_pixel2x2_top.sym} 6120 1570 0 0 {name=x82}
C {openDVS_pixel2x2_top.sym} 6460 1570 0 0 {name=x83}
C {openDVS_pixel2x2_top.sym} 6800 1570 0 0 {name=x84}
C {openDVS_pixel2x2_top.sym} 7140 1570 0 0 {name=x85}
C {openDVS_pixel2x2_top.sym} 7480 1570 0 0 {name=x86}
C {openDVS_pixel2x2_top.sym} 7820 1570 0 0 {name=x87}
C {openDVS_pixel2x2_top.sym} 8160 1570 0 0 {name=x88}
C {openDVS_pixel2x2_top.sym} 8500 1570 0 0 {name=x89}
C {openDVS_pixel2x2_top.sym} 8840 1570 0 0 {name=x90}
C {openDVS_pixel2x2_top.sym} 9180 1570 0 0 {name=x91}
C {openDVS_pixel2x2_top.sym} 9520 1570 0 0 {name=x92}
C {openDVS_pixel2x2_top.sym} 9860 1570 0 0 {name=x93}
C {openDVS_pixel2x2_top.sym} 10200 1570 0 0 {name=x94}
C {openDVS_pixel2x2_top.sym} 10540 1570 0 0 {name=x95}
C {openDVS_pixel2x2_top.sym} 0 2090 0 0 {name=x96}
C {openDVS_pixel2x2_top.sym} 340 2090 0 0 {name=x97}
C {openDVS_pixel2x2_top.sym} 680 2090 0 0 {name=x98}
C {openDVS_pixel2x2_top.sym} 1020 2090 0 0 {name=x99}
C {openDVS_pixel2x2_top.sym} 1360 2090 0 0 {name=x100}
C {openDVS_pixel2x2_top.sym} 1700 2090 0 0 {name=x101}
C {openDVS_pixel2x2_top.sym} 2040 2090 0 0 {name=x102}
C {openDVS_pixel2x2_top.sym} 2380 2090 0 0 {name=x103}
C {openDVS_pixel2x2_top.sym} 2720 2090 0 0 {name=x104}
C {openDVS_pixel2x2_top.sym} 3060 2090 0 0 {name=x105}
C {openDVS_pixel2x2_top.sym} 3400 2090 0 0 {name=x106}
C {openDVS_pixel2x2_top.sym} 3740 2090 0 0 {name=x107}
C {openDVS_pixel2x2_top.sym} 4080 2090 0 0 {name=x108}
C {openDVS_pixel2x2_top.sym} 4420 2090 0 0 {name=x109}
C {openDVS_pixel2x2_top.sym} 4760 2090 0 0 {name=x110}
C {openDVS_pixel2x2_top.sym} 5100 2090 0 0 {name=x111}
C {openDVS_pixel2x2_top.sym} 5440 2090 0 0 {name=x112}
C {openDVS_pixel2x2_top.sym} 5780 2090 0 0 {name=x113}
C {openDVS_pixel2x2_top.sym} 6120 2090 0 0 {name=x114}
C {openDVS_pixel2x2_top.sym} 6460 2090 0 0 {name=x115}
C {openDVS_pixel2x2_top.sym} 6800 2090 0 0 {name=x116}
C {openDVS_pixel2x2_top.sym} 7140 2090 0 0 {name=x117}
C {openDVS_pixel2x2_top.sym} 7480 2090 0 0 {name=x118}
C {openDVS_pixel2x2_top.sym} 7820 2090 0 0 {name=x119}
C {openDVS_pixel2x2_top.sym} 8160 2090 0 0 {name=x120}
C {openDVS_pixel2x2_top.sym} 8500 2090 0 0 {name=x121}
C {openDVS_pixel2x2_top.sym} 8840 2090 0 0 {name=x122}
C {openDVS_pixel2x2_top.sym} 9180 2090 0 0 {name=x123}
C {openDVS_pixel2x2_top.sym} 9520 2090 0 0 {name=x124}
C {openDVS_pixel2x2_top.sym} 9860 2090 0 0 {name=x125}
C {openDVS_pixel2x2_top.sym} 10200 2090 0 0 {name=x126}
C {openDVS_pixel2x2_top.sym} 10540 2090 0 0 {name=x127}
C {openDVS_pixel2x2_top.sym} 0 2610 0 0 {name=x128}
C {openDVS_pixel2x2_top.sym} 340 2610 0 0 {name=x129}
C {openDVS_pixel2x2_top.sym} 680 2610 0 0 {name=x130}
C {openDVS_pixel2x2_top.sym} 1020 2610 0 0 {name=x131}
C {openDVS_pixel2x2_top.sym} 1360 2610 0 0 {name=x132}
C {openDVS_pixel2x2_top.sym} 1700 2610 0 0 {name=x133}
C {openDVS_pixel2x2_top.sym} 2040 2610 0 0 {name=x134}
C {openDVS_pixel2x2_top.sym} 2380 2610 0 0 {name=x135}
C {openDVS_pixel2x2_top.sym} 2720 2610 0 0 {name=x136}
C {openDVS_pixel2x2_top.sym} 3060 2610 0 0 {name=x137}
C {openDVS_pixel2x2_top.sym} 3400 2610 0 0 {name=x138}
C {openDVS_pixel2x2_top.sym} 3740 2610 0 0 {name=x139}
C {openDVS_pixel2x2_top.sym} 4080 2610 0 0 {name=x140}
C {openDVS_pixel2x2_top.sym} 4420 2610 0 0 {name=x141}
C {openDVS_pixel2x2_top.sym} 4760 2610 0 0 {name=x142}
C {openDVS_pixel2x2_top.sym} 5100 2610 0 0 {name=x143}
C {openDVS_pixel2x2_top.sym} 5440 2610 0 0 {name=x144}
C {openDVS_pixel2x2_top.sym} 5780 2610 0 0 {name=x145}
C {openDVS_pixel2x2_top.sym} 6120 2610 0 0 {name=x146}
C {openDVS_pixel2x2_top.sym} 6460 2610 0 0 {name=x147}
C {openDVS_pixel2x2_top.sym} 6800 2610 0 0 {name=x148}
C {openDVS_pixel2x2_top.sym} 7140 2610 0 0 {name=x149}
C {openDVS_pixel2x2_top.sym} 7480 2610 0 0 {name=x150}
C {openDVS_pixel2x2_top.sym} 7820 2610 0 0 {name=x151}
C {openDVS_pixel2x2_top.sym} 8160 2610 0 0 {name=x152}
C {openDVS_pixel2x2_top.sym} 8500 2610 0 0 {name=x153}
C {openDVS_pixel2x2_top.sym} 8840 2610 0 0 {name=x154}
C {openDVS_pixel2x2_top.sym} 9180 2610 0 0 {name=x155}
C {openDVS_pixel2x2_top.sym} 9520 2610 0 0 {name=x156}
C {openDVS_pixel2x2_top.sym} 9860 2610 0 0 {name=x157}
C {openDVS_pixel2x2_top.sym} 10200 2610 0 0 {name=x158}
C {openDVS_pixel2x2_top.sym} 10540 2610 0 0 {name=x159}
C {openDVS_pixel2x2_top.sym} 0 3130 0 0 {name=x160}
C {openDVS_pixel2x2_top.sym} 340 3130 0 0 {name=x161}
C {openDVS_pixel2x2_top.sym} 680 3130 0 0 {name=x162}
C {openDVS_pixel2x2_top.sym} 1020 3130 0 0 {name=x163}
C {openDVS_pixel2x2_top.sym} 1360 3130 0 0 {name=x164}
C {openDVS_pixel2x2_top.sym} 1700 3130 0 0 {name=x165}
C {openDVS_pixel2x2_top.sym} 2040 3130 0 0 {name=x166}
C {openDVS_pixel2x2_top.sym} 2380 3130 0 0 {name=x167}
C {openDVS_pixel2x2_top.sym} 2720 3130 0 0 {name=x168}
C {openDVS_pixel2x2_top.sym} 3060 3130 0 0 {name=x169}
C {openDVS_pixel2x2_top.sym} 3400 3130 0 0 {name=x170}
C {openDVS_pixel2x2_top.sym} 3740 3130 0 0 {name=x171}
C {openDVS_pixel2x2_top.sym} 4080 3130 0 0 {name=x172}
C {openDVS_pixel2x2_top.sym} 4420 3130 0 0 {name=x173}
C {openDVS_pixel2x2_top.sym} 4760 3130 0 0 {name=x174}
C {openDVS_pixel2x2_top.sym} 5100 3130 0 0 {name=x175}
C {openDVS_pixel2x2_top.sym} 5440 3130 0 0 {name=x176}
C {openDVS_pixel2x2_top.sym} 5780 3130 0 0 {name=x177}
C {openDVS_pixel2x2_top.sym} 6120 3130 0 0 {name=x178}
C {openDVS_pixel2x2_top.sym} 6460 3130 0 0 {name=x179}
C {openDVS_pixel2x2_top.sym} 6800 3130 0 0 {name=x180}
C {openDVS_pixel2x2_top.sym} 7140 3130 0 0 {name=x181}
C {openDVS_pixel2x2_top.sym} 7480 3130 0 0 {name=x182}
C {openDVS_pixel2x2_top.sym} 7820 3130 0 0 {name=x183}
C {openDVS_pixel2x2_top.sym} 8160 3130 0 0 {name=x184}
C {openDVS_pixel2x2_top.sym} 8500 3130 0 0 {name=x185}
C {openDVS_pixel2x2_top.sym} 8840 3130 0 0 {name=x186}
C {openDVS_pixel2x2_top.sym} 9180 3130 0 0 {name=x187}
C {openDVS_pixel2x2_top.sym} 9520 3130 0 0 {name=x188}
C {openDVS_pixel2x2_top.sym} 9860 3130 0 0 {name=x189}
C {openDVS_pixel2x2_top.sym} 10200 3130 0 0 {name=x190}
C {openDVS_pixel2x2_top.sym} 10540 3130 0 0 {name=x191}
C {openDVS_pixel2x2_top.sym} 0 3650 0 0 {name=x192}
C {openDVS_pixel2x2_top.sym} 340 3650 0 0 {name=x193}
C {openDVS_pixel2x2_top.sym} 680 3650 0 0 {name=x194}
C {openDVS_pixel2x2_top.sym} 1020 3650 0 0 {name=x195}
C {openDVS_pixel2x2_top.sym} 1360 3650 0 0 {name=x196}
C {openDVS_pixel2x2_top.sym} 1700 3650 0 0 {name=x197}
C {openDVS_pixel2x2_top.sym} 2040 3650 0 0 {name=x198}
C {openDVS_pixel2x2_top.sym} 2380 3650 0 0 {name=x199}
C {openDVS_pixel2x2_top.sym} 2720 3650 0 0 {name=x200}
C {openDVS_pixel2x2_top.sym} 3060 3650 0 0 {name=x201}
C {openDVS_pixel2x2_top.sym} 3400 3650 0 0 {name=x202}
C {openDVS_pixel2x2_top.sym} 3740 3650 0 0 {name=x203}
C {openDVS_pixel2x2_top.sym} 4080 3650 0 0 {name=x204}
C {openDVS_pixel2x2_top.sym} 4420 3650 0 0 {name=x205}
C {openDVS_pixel2x2_top.sym} 4760 3650 0 0 {name=x206}
C {openDVS_pixel2x2_top.sym} 5100 3650 0 0 {name=x207}
C {openDVS_pixel2x2_top.sym} 5440 3650 0 0 {name=x208}
C {openDVS_pixel2x2_top.sym} 5780 3650 0 0 {name=x209}
C {openDVS_pixel2x2_top.sym} 6120 3650 0 0 {name=x210}
C {openDVS_pixel2x2_top.sym} 6460 3650 0 0 {name=x211}
C {openDVS_pixel2x2_top.sym} 6800 3650 0 0 {name=x212}
C {openDVS_pixel2x2_top.sym} 7140 3650 0 0 {name=x213}
C {openDVS_pixel2x2_top.sym} 7480 3650 0 0 {name=x214}
C {openDVS_pixel2x2_top.sym} 7820 3650 0 0 {name=x215}
C {openDVS_pixel2x2_top.sym} 8160 3650 0 0 {name=x216}
C {openDVS_pixel2x2_top.sym} 8500 3650 0 0 {name=x217}
C {openDVS_pixel2x2_top.sym} 8840 3650 0 0 {name=x218}
C {openDVS_pixel2x2_top.sym} 9180 3650 0 0 {name=x219}
C {openDVS_pixel2x2_top.sym} 9520 3650 0 0 {name=x220}
C {openDVS_pixel2x2_top.sym} 9860 3650 0 0 {name=x221}
C {openDVS_pixel2x2_top.sym} 10200 3650 0 0 {name=x222}
C {openDVS_pixel2x2_top.sym} 10540 3650 0 0 {name=x223}
C {openDVS_pixel2x2_top.sym} 0 4170 0 0 {name=x224}
C {openDVS_pixel2x2_top.sym} 340 4170 0 0 {name=x225}
C {openDVS_pixel2x2_top.sym} 680 4170 0 0 {name=x226}
C {openDVS_pixel2x2_top.sym} 1020 4170 0 0 {name=x227}
C {openDVS_pixel2x2_top.sym} 1360 4170 0 0 {name=x228}
C {openDVS_pixel2x2_top.sym} 1700 4170 0 0 {name=x229}
C {openDVS_pixel2x2_top.sym} 2040 4170 0 0 {name=x230}
C {openDVS_pixel2x2_top.sym} 2380 4170 0 0 {name=x231}
C {openDVS_pixel2x2_top.sym} 2720 4170 0 0 {name=x232}
C {openDVS_pixel2x2_top.sym} 3060 4170 0 0 {name=x233}
C {openDVS_pixel2x2_top.sym} 3400 4170 0 0 {name=x234}
C {openDVS_pixel2x2_top.sym} 3740 4170 0 0 {name=x235}
C {openDVS_pixel2x2_top.sym} 4080 4170 0 0 {name=x236}
C {openDVS_pixel2x2_top.sym} 4420 4170 0 0 {name=x237}
C {openDVS_pixel2x2_top.sym} 4760 4170 0 0 {name=x238}
C {openDVS_pixel2x2_top.sym} 5100 4170 0 0 {name=x239}
C {openDVS_pixel2x2_top.sym} 5440 4170 0 0 {name=x240}
C {openDVS_pixel2x2_top.sym} 5780 4170 0 0 {name=x241}
C {openDVS_pixel2x2_top.sym} 6120 4170 0 0 {name=x242}
C {openDVS_pixel2x2_top.sym} 6460 4170 0 0 {name=x243}
C {openDVS_pixel2x2_top.sym} 6800 4170 0 0 {name=x244}
C {openDVS_pixel2x2_top.sym} 7140 4170 0 0 {name=x245}
C {openDVS_pixel2x2_top.sym} 7480 4170 0 0 {name=x246}
C {openDVS_pixel2x2_top.sym} 7820 4170 0 0 {name=x247}
C {openDVS_pixel2x2_top.sym} 8160 4170 0 0 {name=x248}
C {openDVS_pixel2x2_top.sym} 8500 4170 0 0 {name=x249}
C {openDVS_pixel2x2_top.sym} 8840 4170 0 0 {name=x250}
C {openDVS_pixel2x2_top.sym} 9180 4170 0 0 {name=x251}
C {openDVS_pixel2x2_top.sym} 9520 4170 0 0 {name=x252}
C {openDVS_pixel2x2_top.sym} 9860 4170 0 0 {name=x253}
C {openDVS_pixel2x2_top.sym} 10200 4170 0 0 {name=x254}
C {openDVS_pixel2x2_top.sym} 10540 4170 0 0 {name=x255}
C {openDVS_pixel2x2_top.sym} 0 4690 0 0 {name=x256}
C {openDVS_pixel2x2_top.sym} 340 4690 0 0 {name=x257}
C {openDVS_pixel2x2_top.sym} 680 4690 0 0 {name=x258}
C {openDVS_pixel2x2_top.sym} 1020 4690 0 0 {name=x259}
C {openDVS_pixel2x2_top.sym} 1360 4690 0 0 {name=x260}
C {openDVS_pixel2x2_top.sym} 1700 4690 0 0 {name=x261}
C {openDVS_pixel2x2_top.sym} 2040 4690 0 0 {name=x262}
C {openDVS_pixel2x2_top.sym} 2380 4690 0 0 {name=x263}
C {openDVS_pixel2x2_top.sym} 2720 4690 0 0 {name=x264}
C {openDVS_pixel2x2_top.sym} 3060 4690 0 0 {name=x265}
C {openDVS_pixel2x2_top.sym} 3400 4690 0 0 {name=x266}
C {openDVS_pixel2x2_top.sym} 3740 4690 0 0 {name=x267}
C {openDVS_pixel2x2_top.sym} 4080 4690 0 0 {name=x268}
C {openDVS_pixel2x2_top.sym} 4420 4690 0 0 {name=x269}
C {openDVS_pixel2x2_top.sym} 4760 4690 0 0 {name=x270}
C {openDVS_pixel2x2_top.sym} 5100 4690 0 0 {name=x271}
C {openDVS_pixel2x2_top.sym} 5440 4690 0 0 {name=x272}
C {openDVS_pixel2x2_top.sym} 5780 4690 0 0 {name=x273}
C {openDVS_pixel2x2_top.sym} 6120 4690 0 0 {name=x274}
C {openDVS_pixel2x2_top.sym} 6460 4690 0 0 {name=x275}
C {openDVS_pixel2x2_top.sym} 6800 4690 0 0 {name=x276}
C {openDVS_pixel2x2_top.sym} 7140 4690 0 0 {name=x277}
C {openDVS_pixel2x2_top.sym} 7480 4690 0 0 {name=x278}
C {openDVS_pixel2x2_top.sym} 7820 4690 0 0 {name=x279}
C {openDVS_pixel2x2_top.sym} 8160 4690 0 0 {name=x280}
C {openDVS_pixel2x2_top.sym} 8500 4690 0 0 {name=x281}
C {openDVS_pixel2x2_top.sym} 8840 4690 0 0 {name=x282}
C {openDVS_pixel2x2_top.sym} 9180 4690 0 0 {name=x283}
C {openDVS_pixel2x2_top.sym} 9520 4690 0 0 {name=x284}
C {openDVS_pixel2x2_top.sym} 9860 4690 0 0 {name=x285}
C {openDVS_pixel2x2_top.sym} 10200 4690 0 0 {name=x286}
C {openDVS_pixel2x2_top.sym} 10540 4690 0 0 {name=x287}
C {openDVS_pixel2x2_top.sym} 0 5210 0 0 {name=x288}
C {openDVS_pixel2x2_top.sym} 340 5210 0 0 {name=x289}
C {openDVS_pixel2x2_top.sym} 680 5210 0 0 {name=x290}
C {openDVS_pixel2x2_top.sym} 1020 5210 0 0 {name=x291}
C {openDVS_pixel2x2_top.sym} 1360 5210 0 0 {name=x292}
C {openDVS_pixel2x2_top.sym} 1700 5210 0 0 {name=x293}
C {openDVS_pixel2x2_top.sym} 2040 5210 0 0 {name=x294}
C {openDVS_pixel2x2_top.sym} 2380 5210 0 0 {name=x295}
C {openDVS_pixel2x2_top.sym} 2720 5210 0 0 {name=x296}
C {openDVS_pixel2x2_top.sym} 3060 5210 0 0 {name=x297}
C {openDVS_pixel2x2_top.sym} 3400 5210 0 0 {name=x298}
C {openDVS_pixel2x2_top.sym} 3740 5210 0 0 {name=x299}
C {openDVS_pixel2x2_top.sym} 4080 5210 0 0 {name=x300}
C {openDVS_pixel2x2_top.sym} 4420 5210 0 0 {name=x301}
C {openDVS_pixel2x2_top.sym} 4760 5210 0 0 {name=x302}
C {openDVS_pixel2x2_top.sym} 5100 5210 0 0 {name=x303}
C {openDVS_pixel2x2_top.sym} 5440 5210 0 0 {name=x304}
C {openDVS_pixel2x2_top.sym} 5780 5210 0 0 {name=x305}
C {openDVS_pixel2x2_top.sym} 6120 5210 0 0 {name=x306}
C {openDVS_pixel2x2_top.sym} 6460 5210 0 0 {name=x307}
C {openDVS_pixel2x2_top.sym} 6800 5210 0 0 {name=x308}
C {openDVS_pixel2x2_top.sym} 7140 5210 0 0 {name=x309}
C {openDVS_pixel2x2_top.sym} 7480 5210 0 0 {name=x310}
C {openDVS_pixel2x2_top.sym} 7820 5210 0 0 {name=x311}
C {openDVS_pixel2x2_top.sym} 8160 5210 0 0 {name=x312}
C {openDVS_pixel2x2_top.sym} 8500 5210 0 0 {name=x313}
C {openDVS_pixel2x2_top.sym} 8840 5210 0 0 {name=x314}
C {openDVS_pixel2x2_top.sym} 9180 5210 0 0 {name=x315}
C {openDVS_pixel2x2_top.sym} 9520 5210 0 0 {name=x316}
C {openDVS_pixel2x2_top.sym} 9860 5210 0 0 {name=x317}
C {openDVS_pixel2x2_top.sym} 10200 5210 0 0 {name=x318}
C {openDVS_pixel2x2_top.sym} 10540 5210 0 0 {name=x319}
C {openDVS_pixel2x2_top.sym} 0 5730 0 0 {name=x320}
C {openDVS_pixel2x2_top.sym} 340 5730 0 0 {name=x321}
C {openDVS_pixel2x2_top.sym} 680 5730 0 0 {name=x322}
C {openDVS_pixel2x2_top.sym} 1020 5730 0 0 {name=x323}
C {openDVS_pixel2x2_top.sym} 1360 5730 0 0 {name=x324}
C {openDVS_pixel2x2_top.sym} 1700 5730 0 0 {name=x325}
C {openDVS_pixel2x2_top.sym} 2040 5730 0 0 {name=x326}
C {openDVS_pixel2x2_top.sym} 2380 5730 0 0 {name=x327}
C {openDVS_pixel2x2_top.sym} 2720 5730 0 0 {name=x328}
C {openDVS_pixel2x2_top.sym} 3060 5730 0 0 {name=x329}
C {openDVS_pixel2x2_top.sym} 3400 5730 0 0 {name=x330}
C {openDVS_pixel2x2_top.sym} 3740 5730 0 0 {name=x331}
C {openDVS_pixel2x2_top.sym} 4080 5730 0 0 {name=x332}
C {openDVS_pixel2x2_top.sym} 4420 5730 0 0 {name=x333}
C {openDVS_pixel2x2_top.sym} 4760 5730 0 0 {name=x334}
C {openDVS_pixel2x2_top.sym} 5100 5730 0 0 {name=x335}
C {openDVS_pixel2x2_top.sym} 5440 5730 0 0 {name=x336}
C {openDVS_pixel2x2_top.sym} 5780 5730 0 0 {name=x337}
C {openDVS_pixel2x2_top.sym} 6120 5730 0 0 {name=x338}
C {openDVS_pixel2x2_top.sym} 6460 5730 0 0 {name=x339}
C {openDVS_pixel2x2_top.sym} 6800 5730 0 0 {name=x340}
C {openDVS_pixel2x2_top.sym} 7140 5730 0 0 {name=x341}
C {openDVS_pixel2x2_top.sym} 7480 5730 0 0 {name=x342}
C {openDVS_pixel2x2_top.sym} 7820 5730 0 0 {name=x343}
C {openDVS_pixel2x2_top.sym} 8160 5730 0 0 {name=x344}
C {openDVS_pixel2x2_top.sym} 8500 5730 0 0 {name=x345}
C {openDVS_pixel2x2_top.sym} 8840 5730 0 0 {name=x346}
C {openDVS_pixel2x2_top.sym} 9180 5730 0 0 {name=x347}
C {openDVS_pixel2x2_top.sym} 9520 5730 0 0 {name=x348}
C {openDVS_pixel2x2_top.sym} 9860 5730 0 0 {name=x349}
C {openDVS_pixel2x2_top.sym} 10200 5730 0 0 {name=x350}
C {openDVS_pixel2x2_top.sym} 10540 5730 0 0 {name=x351}
C {openDVS_pixel2x2_top.sym} 0 6250 0 0 {name=x352}
C {openDVS_pixel2x2_top.sym} 340 6250 0 0 {name=x353}
C {openDVS_pixel2x2_top.sym} 680 6250 0 0 {name=x354}
C {openDVS_pixel2x2_top.sym} 1020 6250 0 0 {name=x355}
C {openDVS_pixel2x2_top.sym} 1360 6250 0 0 {name=x356}
C {openDVS_pixel2x2_top.sym} 1700 6250 0 0 {name=x357}
C {openDVS_pixel2x2_top.sym} 2040 6250 0 0 {name=x358}
C {openDVS_pixel2x2_top.sym} 2380 6250 0 0 {name=x359}
C {openDVS_pixel2x2_top.sym} 2720 6250 0 0 {name=x360}
C {openDVS_pixel2x2_top.sym} 3060 6250 0 0 {name=x361}
C {openDVS_pixel2x2_top.sym} 3400 6250 0 0 {name=x362}
C {openDVS_pixel2x2_top.sym} 3740 6250 0 0 {name=x363}
C {openDVS_pixel2x2_top.sym} 4080 6250 0 0 {name=x364}
C {openDVS_pixel2x2_top.sym} 4420 6250 0 0 {name=x365}
C {openDVS_pixel2x2_top.sym} 4760 6250 0 0 {name=x366}
C {openDVS_pixel2x2_top.sym} 5100 6250 0 0 {name=x367}
C {openDVS_pixel2x2_top.sym} 5440 6250 0 0 {name=x368}
C {openDVS_pixel2x2_top.sym} 5780 6250 0 0 {name=x369}
C {openDVS_pixel2x2_top.sym} 6120 6250 0 0 {name=x370}
C {openDVS_pixel2x2_top.sym} 6460 6250 0 0 {name=x371}
C {openDVS_pixel2x2_top.sym} 6800 6250 0 0 {name=x372}
C {openDVS_pixel2x2_top.sym} 7140 6250 0 0 {name=x373}
C {openDVS_pixel2x2_top.sym} 7480 6250 0 0 {name=x374}
C {openDVS_pixel2x2_top.sym} 7820 6250 0 0 {name=x375}
C {openDVS_pixel2x2_top.sym} 8160 6250 0 0 {name=x376}
C {openDVS_pixel2x2_top.sym} 8500 6250 0 0 {name=x377}
C {openDVS_pixel2x2_top.sym} 8840 6250 0 0 {name=x378}
C {openDVS_pixel2x2_top.sym} 9180 6250 0 0 {name=x379}
C {openDVS_pixel2x2_top.sym} 9520 6250 0 0 {name=x380}
C {openDVS_pixel2x2_top.sym} 9860 6250 0 0 {name=x381}
C {openDVS_pixel2x2_top.sym} 10200 6250 0 0 {name=x382}
C {openDVS_pixel2x2_top.sym} 10540 6250 0 0 {name=x383}
C {openDVS_pixel2x2_top.sym} 0 6770 0 0 {name=x384}
C {openDVS_pixel2x2_top.sym} 340 6770 0 0 {name=x385}
C {openDVS_pixel2x2_top.sym} 680 6770 0 0 {name=x386}
C {openDVS_pixel2x2_top.sym} 1020 6770 0 0 {name=x387}
C {openDVS_pixel2x2_top.sym} 1360 6770 0 0 {name=x388}
C {openDVS_pixel2x2_top.sym} 1700 6770 0 0 {name=x389}
C {openDVS_pixel2x2_top.sym} 2040 6770 0 0 {name=x390}
C {openDVS_pixel2x2_top.sym} 2380 6770 0 0 {name=x391}
C {openDVS_pixel2x2_top.sym} 2720 6770 0 0 {name=x392}
C {openDVS_pixel2x2_top.sym} 3060 6770 0 0 {name=x393}
C {openDVS_pixel2x2_top.sym} 3400 6770 0 0 {name=x394}
C {openDVS_pixel2x2_top.sym} 3740 6770 0 0 {name=x395}
C {openDVS_pixel2x2_top.sym} 4080 6770 0 0 {name=x396}
C {openDVS_pixel2x2_top.sym} 4420 6770 0 0 {name=x397}
C {openDVS_pixel2x2_top.sym} 4760 6770 0 0 {name=x398}
C {openDVS_pixel2x2_top.sym} 5100 6770 0 0 {name=x399}
C {openDVS_pixel2x2_top.sym} 5440 6770 0 0 {name=x400}
C {openDVS_pixel2x2_top.sym} 5780 6770 0 0 {name=x401}
C {openDVS_pixel2x2_top.sym} 6120 6770 0 0 {name=x402}
C {openDVS_pixel2x2_top.sym} 6460 6770 0 0 {name=x403}
C {openDVS_pixel2x2_top.sym} 6800 6770 0 0 {name=x404}
C {openDVS_pixel2x2_top.sym} 7140 6770 0 0 {name=x405}
C {openDVS_pixel2x2_top.sym} 7480 6770 0 0 {name=x406}
C {openDVS_pixel2x2_top.sym} 7820 6770 0 0 {name=x407}
C {openDVS_pixel2x2_top.sym} 8160 6770 0 0 {name=x408}
C {openDVS_pixel2x2_top.sym} 8500 6770 0 0 {name=x409}
C {openDVS_pixel2x2_top.sym} 8840 6770 0 0 {name=x410}
C {openDVS_pixel2x2_top.sym} 9180 6770 0 0 {name=x411}
C {openDVS_pixel2x2_top.sym} 9520 6770 0 0 {name=x412}
C {openDVS_pixel2x2_top.sym} 9860 6770 0 0 {name=x413}
C {openDVS_pixel2x2_top.sym} 10200 6770 0 0 {name=x414}
C {openDVS_pixel2x2_top.sym} 10540 6770 0 0 {name=x415}
C {openDVS_pixel2x2_top.sym} 0 7290 0 0 {name=x416}
C {openDVS_pixel2x2_top.sym} 340 7290 0 0 {name=x417}
C {openDVS_pixel2x2_top.sym} 680 7290 0 0 {name=x418}
C {openDVS_pixel2x2_top.sym} 1020 7290 0 0 {name=x419}
C {openDVS_pixel2x2_top.sym} 1360 7290 0 0 {name=x420}
C {openDVS_pixel2x2_top.sym} 1700 7290 0 0 {name=x421}
C {openDVS_pixel2x2_top.sym} 2040 7290 0 0 {name=x422}
C {openDVS_pixel2x2_top.sym} 2380 7290 0 0 {name=x423}
C {openDVS_pixel2x2_top.sym} 2720 7290 0 0 {name=x424}
C {openDVS_pixel2x2_top.sym} 3060 7290 0 0 {name=x425}
C {openDVS_pixel2x2_top.sym} 3400 7290 0 0 {name=x426}
C {openDVS_pixel2x2_top.sym} 3740 7290 0 0 {name=x427}
C {openDVS_pixel2x2_top.sym} 4080 7290 0 0 {name=x428}
C {openDVS_pixel2x2_top.sym} 4420 7290 0 0 {name=x429}
C {openDVS_pixel2x2_top.sym} 4760 7290 0 0 {name=x430}
C {openDVS_pixel2x2_top.sym} 5100 7290 0 0 {name=x431}
C {openDVS_pixel2x2_top.sym} 5440 7290 0 0 {name=x432}
C {openDVS_pixel2x2_top.sym} 5780 7290 0 0 {name=x433}
C {openDVS_pixel2x2_top.sym} 6120 7290 0 0 {name=x434}
C {openDVS_pixel2x2_top.sym} 6460 7290 0 0 {name=x435}
C {openDVS_pixel2x2_top.sym} 6800 7290 0 0 {name=x436}
C {openDVS_pixel2x2_top.sym} 7140 7290 0 0 {name=x437}
C {openDVS_pixel2x2_top.sym} 7480 7290 0 0 {name=x438}
C {openDVS_pixel2x2_top.sym} 7820 7290 0 0 {name=x439}
C {openDVS_pixel2x2_top.sym} 8160 7290 0 0 {name=x440}
C {openDVS_pixel2x2_top.sym} 8500 7290 0 0 {name=x441}
C {openDVS_pixel2x2_top.sym} 8840 7290 0 0 {name=x442}
C {openDVS_pixel2x2_top.sym} 9180 7290 0 0 {name=x443}
C {openDVS_pixel2x2_top.sym} 9520 7290 0 0 {name=x444}
C {openDVS_pixel2x2_top.sym} 9860 7290 0 0 {name=x445}
C {openDVS_pixel2x2_top.sym} 10200 7290 0 0 {name=x446}
C {openDVS_pixel2x2_top.sym} 10540 7290 0 0 {name=x447}
C {openDVS_pixel2x2_top.sym} 0 7810 0 0 {name=x448}
C {openDVS_pixel2x2_top.sym} 340 7810 0 0 {name=x449}
C {openDVS_pixel2x2_top.sym} 680 7810 0 0 {name=x450}
C {openDVS_pixel2x2_top.sym} 1020 7810 0 0 {name=x451}
C {openDVS_pixel2x2_top.sym} 1360 7810 0 0 {name=x452}
C {openDVS_pixel2x2_top.sym} 1700 7810 0 0 {name=x453}
C {openDVS_pixel2x2_top.sym} 2040 7810 0 0 {name=x454}
C {openDVS_pixel2x2_top.sym} 2380 7810 0 0 {name=x455}
C {openDVS_pixel2x2_top.sym} 2720 7810 0 0 {name=x456}
C {openDVS_pixel2x2_top.sym} 3060 7810 0 0 {name=x457}
C {openDVS_pixel2x2_top.sym} 3400 7810 0 0 {name=x458}
C {openDVS_pixel2x2_top.sym} 3740 7810 0 0 {name=x459}
C {openDVS_pixel2x2_top.sym} 4080 7810 0 0 {name=x460}
C {openDVS_pixel2x2_top.sym} 4420 7810 0 0 {name=x461}
C {openDVS_pixel2x2_top.sym} 4760 7810 0 0 {name=x462}
C {openDVS_pixel2x2_top.sym} 5100 7810 0 0 {name=x463}
C {openDVS_pixel2x2_top.sym} 5440 7810 0 0 {name=x464}
C {openDVS_pixel2x2_top.sym} 5780 7810 0 0 {name=x465}
C {openDVS_pixel2x2_top.sym} 6120 7810 0 0 {name=x466}
C {openDVS_pixel2x2_top.sym} 6460 7810 0 0 {name=x467}
C {openDVS_pixel2x2_top.sym} 6800 7810 0 0 {name=x468}
C {openDVS_pixel2x2_top.sym} 7140 7810 0 0 {name=x469}
C {openDVS_pixel2x2_top.sym} 7480 7810 0 0 {name=x470}
C {openDVS_pixel2x2_top.sym} 7820 7810 0 0 {name=x471}
C {openDVS_pixel2x2_top.sym} 8160 7810 0 0 {name=x472}
C {openDVS_pixel2x2_top.sym} 8500 7810 0 0 {name=x473}
C {openDVS_pixel2x2_top.sym} 8840 7810 0 0 {name=x474}
C {openDVS_pixel2x2_top.sym} 9180 7810 0 0 {name=x475}
C {openDVS_pixel2x2_top.sym} 9520 7810 0 0 {name=x476}
C {openDVS_pixel2x2_top.sym} 9860 7810 0 0 {name=x477}
C {openDVS_pixel2x2_top.sym} 10200 7810 0 0 {name=x478}
C {openDVS_pixel2x2_top.sym} 10540 7810 0 0 {name=x479}
C {openDVS_pixel2x2_top.sym} 0 8330 0 0 {name=x480}
C {openDVS_pixel2x2_top.sym} 340 8330 0 0 {name=x481}
C {openDVS_pixel2x2_top.sym} 680 8330 0 0 {name=x482}
C {openDVS_pixel2x2_top.sym} 1020 8330 0 0 {name=x483}
C {openDVS_pixel2x2_top.sym} 1360 8330 0 0 {name=x484}
C {openDVS_pixel2x2_top.sym} 1700 8330 0 0 {name=x485}
C {openDVS_pixel2x2_top.sym} 2040 8330 0 0 {name=x486}
C {openDVS_pixel2x2_top.sym} 2380 8330 0 0 {name=x487}
C {openDVS_pixel2x2_top.sym} 2720 8330 0 0 {name=x488}
C {openDVS_pixel2x2_top.sym} 3060 8330 0 0 {name=x489}
C {openDVS_pixel2x2_top.sym} 3400 8330 0 0 {name=x490}
C {openDVS_pixel2x2_top.sym} 3740 8330 0 0 {name=x491}
C {openDVS_pixel2x2_top.sym} 4080 8330 0 0 {name=x492}
C {openDVS_pixel2x2_top.sym} 4420 8330 0 0 {name=x493}
C {openDVS_pixel2x2_top.sym} 4760 8330 0 0 {name=x494}
C {openDVS_pixel2x2_top.sym} 5100 8330 0 0 {name=x495}
C {openDVS_pixel2x2_top.sym} 5440 8330 0 0 {name=x496}
C {openDVS_pixel2x2_top.sym} 5780 8330 0 0 {name=x497}
C {openDVS_pixel2x2_top.sym} 6120 8330 0 0 {name=x498}
C {openDVS_pixel2x2_top.sym} 6460 8330 0 0 {name=x499}
C {openDVS_pixel2x2_top.sym} 6800 8330 0 0 {name=x500}
C {openDVS_pixel2x2_top.sym} 7140 8330 0 0 {name=x501}
C {openDVS_pixel2x2_top.sym} 7480 8330 0 0 {name=x502}
C {openDVS_pixel2x2_top.sym} 7820 8330 0 0 {name=x503}
C {openDVS_pixel2x2_top.sym} 8160 8330 0 0 {name=x504}
C {openDVS_pixel2x2_top.sym} 8500 8330 0 0 {name=x505}
C {openDVS_pixel2x2_top.sym} 8840 8330 0 0 {name=x506}
C {openDVS_pixel2x2_top.sym} 9180 8330 0 0 {name=x507}
C {openDVS_pixel2x2_top.sym} 9520 8330 0 0 {name=x508}
C {openDVS_pixel2x2_top.sym} 9860 8330 0 0 {name=x509}
C {openDVS_pixel2x2_top.sym} 10200 8330 0 0 {name=x510}
C {openDVS_pixel2x2_top.sym} 10540 8330 0 0 {name=x511}
C {openDVS_pixel2x2_top.sym} 0 8850 0 0 {name=x512}
C {openDVS_pixel2x2_top.sym} 340 8850 0 0 {name=x513}
C {openDVS_pixel2x2_top.sym} 680 8850 0 0 {name=x514}
C {openDVS_pixel2x2_top.sym} 1020 8850 0 0 {name=x515}
C {openDVS_pixel2x2_top.sym} 1360 8850 0 0 {name=x516}
C {openDVS_pixel2x2_top.sym} 1700 8850 0 0 {name=x517}
C {openDVS_pixel2x2_top.sym} 2040 8850 0 0 {name=x518}
C {openDVS_pixel2x2_top.sym} 2380 8850 0 0 {name=x519}
C {openDVS_pixel2x2_top.sym} 2720 8850 0 0 {name=x520}
C {openDVS_pixel2x2_top.sym} 3060 8850 0 0 {name=x521}
C {openDVS_pixel2x2_top.sym} 3400 8850 0 0 {name=x522}
C {openDVS_pixel2x2_top.sym} 3740 8850 0 0 {name=x523}
C {openDVS_pixel2x2_top.sym} 4080 8850 0 0 {name=x524}
C {openDVS_pixel2x2_top.sym} 4420 8850 0 0 {name=x525}
C {openDVS_pixel2x2_top.sym} 4760 8850 0 0 {name=x526}
C {openDVS_pixel2x2_top.sym} 5100 8850 0 0 {name=x527}
C {openDVS_pixel2x2_top.sym} 5440 8850 0 0 {name=x528}
C {openDVS_pixel2x2_top.sym} 5780 8850 0 0 {name=x529}
C {openDVS_pixel2x2_top.sym} 6120 8850 0 0 {name=x530}
C {openDVS_pixel2x2_top.sym} 6460 8850 0 0 {name=x531}
C {openDVS_pixel2x2_top.sym} 6800 8850 0 0 {name=x532}
C {openDVS_pixel2x2_top.sym} 7140 8850 0 0 {name=x533}
C {openDVS_pixel2x2_top.sym} 7480 8850 0 0 {name=x534}
C {openDVS_pixel2x2_top.sym} 7820 8850 0 0 {name=x535}
C {openDVS_pixel2x2_top.sym} 8160 8850 0 0 {name=x536}
C {openDVS_pixel2x2_top.sym} 8500 8850 0 0 {name=x537}
C {openDVS_pixel2x2_top.sym} 8840 8850 0 0 {name=x538}
C {openDVS_pixel2x2_top.sym} 9180 8850 0 0 {name=x539}
C {openDVS_pixel2x2_top.sym} 9520 8850 0 0 {name=x540}
C {openDVS_pixel2x2_top.sym} 9860 8850 0 0 {name=x541}
C {openDVS_pixel2x2_top.sym} 10200 8850 0 0 {name=x542}
C {openDVS_pixel2x2_top.sym} 10540 8850 0 0 {name=x543}
C {openDVS_pixel2x2_top.sym} 0 9370 0 0 {name=x544}
C {openDVS_pixel2x2_top.sym} 340 9370 0 0 {name=x545}
C {openDVS_pixel2x2_top.sym} 680 9370 0 0 {name=x546}
C {openDVS_pixel2x2_top.sym} 1020 9370 0 0 {name=x547}
C {openDVS_pixel2x2_top.sym} 1360 9370 0 0 {name=x548}
C {openDVS_pixel2x2_top.sym} 1700 9370 0 0 {name=x549}
C {openDVS_pixel2x2_top.sym} 2040 9370 0 0 {name=x550}
C {openDVS_pixel2x2_top.sym} 2380 9370 0 0 {name=x551}
C {openDVS_pixel2x2_top.sym} 2720 9370 0 0 {name=x552}
C {openDVS_pixel2x2_top.sym} 3060 9370 0 0 {name=x553}
C {openDVS_pixel2x2_top.sym} 3400 9370 0 0 {name=x554}
C {openDVS_pixel2x2_top.sym} 3740 9370 0 0 {name=x555}
C {openDVS_pixel2x2_top.sym} 4080 9370 0 0 {name=x556}
C {openDVS_pixel2x2_top.sym} 4420 9370 0 0 {name=x557}
C {openDVS_pixel2x2_top.sym} 4760 9370 0 0 {name=x558}
C {openDVS_pixel2x2_top.sym} 5100 9370 0 0 {name=x559}
C {openDVS_pixel2x2_top.sym} 5440 9370 0 0 {name=x560}
C {openDVS_pixel2x2_top.sym} 5780 9370 0 0 {name=x561}
C {openDVS_pixel2x2_top.sym} 6120 9370 0 0 {name=x562}
C {openDVS_pixel2x2_top.sym} 6460 9370 0 0 {name=x563}
C {openDVS_pixel2x2_top.sym} 6800 9370 0 0 {name=x564}
C {openDVS_pixel2x2_top.sym} 7140 9370 0 0 {name=x565}
C {openDVS_pixel2x2_top.sym} 7480 9370 0 0 {name=x566}
C {openDVS_pixel2x2_top.sym} 7820 9370 0 0 {name=x567}
C {openDVS_pixel2x2_top.sym} 8160 9370 0 0 {name=x568}
C {openDVS_pixel2x2_top.sym} 8500 9370 0 0 {name=x569}
C {openDVS_pixel2x2_top.sym} 8840 9370 0 0 {name=x570}
C {openDVS_pixel2x2_top.sym} 9180 9370 0 0 {name=x571}
C {openDVS_pixel2x2_top.sym} 9520 9370 0 0 {name=x572}
C {openDVS_pixel2x2_top.sym} 9860 9370 0 0 {name=x573}
C {openDVS_pixel2x2_top.sym} 10200 9370 0 0 {name=x574}
C {openDVS_pixel2x2_top.sym} 10540 9370 0 0 {name=x575}
C {openDVS_pixel2x2_top.sym} 0 9890 0 0 {name=x576}
C {openDVS_pixel2x2_top.sym} 340 9890 0 0 {name=x577}
C {openDVS_pixel2x2_top.sym} 680 9890 0 0 {name=x578}
C {openDVS_pixel2x2_top.sym} 1020 9890 0 0 {name=x579}
C {openDVS_pixel2x2_top.sym} 1360 9890 0 0 {name=x580}
C {openDVS_pixel2x2_top.sym} 1700 9890 0 0 {name=x581}
C {openDVS_pixel2x2_top.sym} 2040 9890 0 0 {name=x582}
C {openDVS_pixel2x2_top.sym} 2380 9890 0 0 {name=x583}
C {openDVS_pixel2x2_top.sym} 2720 9890 0 0 {name=x584}
C {openDVS_pixel2x2_top.sym} 3060 9890 0 0 {name=x585}
C {openDVS_pixel2x2_top.sym} 3400 9890 0 0 {name=x586}
C {openDVS_pixel2x2_top.sym} 3740 9890 0 0 {name=x587}
C {openDVS_pixel2x2_top.sym} 4080 9890 0 0 {name=x588}
C {openDVS_pixel2x2_top.sym} 4420 9890 0 0 {name=x589}
C {openDVS_pixel2x2_top.sym} 4760 9890 0 0 {name=x590}
C {openDVS_pixel2x2_top.sym} 5100 9890 0 0 {name=x591}
C {openDVS_pixel2x2_top.sym} 5440 9890 0 0 {name=x592}
C {openDVS_pixel2x2_top.sym} 5780 9890 0 0 {name=x593}
C {openDVS_pixel2x2_top.sym} 6120 9890 0 0 {name=x594}
C {openDVS_pixel2x2_top.sym} 6460 9890 0 0 {name=x595}
C {openDVS_pixel2x2_top.sym} 6800 9890 0 0 {name=x596}
C {openDVS_pixel2x2_top.sym} 7140 9890 0 0 {name=x597}
C {openDVS_pixel2x2_top.sym} 7480 9890 0 0 {name=x598}
C {openDVS_pixel2x2_top.sym} 7820 9890 0 0 {name=x599}
C {openDVS_pixel2x2_top.sym} 8160 9890 0 0 {name=x600}
C {openDVS_pixel2x2_top.sym} 8500 9890 0 0 {name=x601}
C {openDVS_pixel2x2_top.sym} 8840 9890 0 0 {name=x602}
C {openDVS_pixel2x2_top.sym} 9180 9890 0 0 {name=x603}
C {openDVS_pixel2x2_top.sym} 9520 9890 0 0 {name=x604}
C {openDVS_pixel2x2_top.sym} 9860 9890 0 0 {name=x605}
C {openDVS_pixel2x2_top.sym} 10200 9890 0 0 {name=x606}
C {openDVS_pixel2x2_top.sym} 10540 9890 0 0 {name=x607}
C {openDVS_pixel2x2_top.sym} 0 10410 0 0 {name=x608}
C {openDVS_pixel2x2_top.sym} 340 10410 0 0 {name=x609}
C {openDVS_pixel2x2_top.sym} 680 10410 0 0 {name=x610}
C {openDVS_pixel2x2_top.sym} 1020 10410 0 0 {name=x611}
C {openDVS_pixel2x2_top.sym} 1360 10410 0 0 {name=x612}
C {openDVS_pixel2x2_top.sym} 1700 10410 0 0 {name=x613}
C {openDVS_pixel2x2_top.sym} 2040 10410 0 0 {name=x614}
C {openDVS_pixel2x2_top.sym} 2380 10410 0 0 {name=x615}
C {openDVS_pixel2x2_top.sym} 2720 10410 0 0 {name=x616}
C {openDVS_pixel2x2_top.sym} 3060 10410 0 0 {name=x617}
C {openDVS_pixel2x2_top.sym} 3400 10410 0 0 {name=x618}
C {openDVS_pixel2x2_top.sym} 3740 10410 0 0 {name=x619}
C {openDVS_pixel2x2_top.sym} 4080 10410 0 0 {name=x620}
C {openDVS_pixel2x2_top.sym} 4420 10410 0 0 {name=x621}
C {openDVS_pixel2x2_top.sym} 4760 10410 0 0 {name=x622}
C {openDVS_pixel2x2_top.sym} 5100 10410 0 0 {name=x623}
C {openDVS_pixel2x2_top.sym} 5440 10410 0 0 {name=x624}
C {openDVS_pixel2x2_top.sym} 5780 10410 0 0 {name=x625}
C {openDVS_pixel2x2_top.sym} 6120 10410 0 0 {name=x626}
C {openDVS_pixel2x2_top.sym} 6460 10410 0 0 {name=x627}
C {openDVS_pixel2x2_top.sym} 6800 10410 0 0 {name=x628}
C {openDVS_pixel2x2_top.sym} 7140 10410 0 0 {name=x629}
C {openDVS_pixel2x2_top.sym} 7480 10410 0 0 {name=x630}
C {openDVS_pixel2x2_top.sym} 7820 10410 0 0 {name=x631}
C {openDVS_pixel2x2_top.sym} 8160 10410 0 0 {name=x632}
C {openDVS_pixel2x2_top.sym} 8500 10410 0 0 {name=x633}
C {openDVS_pixel2x2_top.sym} 8840 10410 0 0 {name=x634}
C {openDVS_pixel2x2_top.sym} 9180 10410 0 0 {name=x635}
C {openDVS_pixel2x2_top.sym} 9520 10410 0 0 {name=x636}
C {openDVS_pixel2x2_top.sym} 9860 10410 0 0 {name=x637}
C {openDVS_pixel2x2_top.sym} 10200 10410 0 0 {name=x638}
C {openDVS_pixel2x2_top.sym} 10540 10410 0 0 {name=x639}
C {openDVS_pixel2x2_top.sym} 0 10930 0 0 {name=x640}
C {openDVS_pixel2x2_top.sym} 340 10930 0 0 {name=x641}
C {openDVS_pixel2x2_top.sym} 680 10930 0 0 {name=x642}
C {openDVS_pixel2x2_top.sym} 1020 10930 0 0 {name=x643}
C {openDVS_pixel2x2_top.sym} 1360 10930 0 0 {name=x644}
C {openDVS_pixel2x2_top.sym} 1700 10930 0 0 {name=x645}
C {openDVS_pixel2x2_top.sym} 2040 10930 0 0 {name=x646}
C {openDVS_pixel2x2_top.sym} 2380 10930 0 0 {name=x647}
C {openDVS_pixel2x2_top.sym} 2720 10930 0 0 {name=x648}
C {openDVS_pixel2x2_top.sym} 3060 10930 0 0 {name=x649}
C {openDVS_pixel2x2_top.sym} 3400 10930 0 0 {name=x650}
C {openDVS_pixel2x2_top.sym} 3740 10930 0 0 {name=x651}
C {openDVS_pixel2x2_top.sym} 4080 10930 0 0 {name=x652}
C {openDVS_pixel2x2_top.sym} 4420 10930 0 0 {name=x653}
C {openDVS_pixel2x2_top.sym} 4760 10930 0 0 {name=x654}
C {openDVS_pixel2x2_top.sym} 5100 10930 0 0 {name=x655}
C {openDVS_pixel2x2_top.sym} 5440 10930 0 0 {name=x656}
C {openDVS_pixel2x2_top.sym} 5780 10930 0 0 {name=x657}
C {openDVS_pixel2x2_top.sym} 6120 10930 0 0 {name=x658}
C {openDVS_pixel2x2_top.sym} 6460 10930 0 0 {name=x659}
C {openDVS_pixel2x2_top.sym} 6800 10930 0 0 {name=x660}
C {openDVS_pixel2x2_top.sym} 7140 10930 0 0 {name=x661}
C {openDVS_pixel2x2_top.sym} 7480 10930 0 0 {name=x662}
C {openDVS_pixel2x2_top.sym} 7820 10930 0 0 {name=x663}
C {openDVS_pixel2x2_top.sym} 8160 10930 0 0 {name=x664}
C {openDVS_pixel2x2_top.sym} 8500 10930 0 0 {name=x665}
C {openDVS_pixel2x2_top.sym} 8840 10930 0 0 {name=x666}
C {openDVS_pixel2x2_top.sym} 9180 10930 0 0 {name=x667}
C {openDVS_pixel2x2_top.sym} 9520 10930 0 0 {name=x668}
C {openDVS_pixel2x2_top.sym} 9860 10930 0 0 {name=x669}
C {openDVS_pixel2x2_top.sym} 10200 10930 0 0 {name=x670}
C {openDVS_pixel2x2_top.sym} 10540 10930 0 0 {name=x671}
C {openDVS_pixel2x2_top.sym} 0 11450 0 0 {name=x672}
C {openDVS_pixel2x2_top.sym} 340 11450 0 0 {name=x673}
C {openDVS_pixel2x2_top.sym} 680 11450 0 0 {name=x674}
C {openDVS_pixel2x2_top.sym} 1020 11450 0 0 {name=x675}
C {openDVS_pixel2x2_top.sym} 1360 11450 0 0 {name=x676}
C {openDVS_pixel2x2_top.sym} 1700 11450 0 0 {name=x677}
C {openDVS_pixel2x2_top.sym} 2040 11450 0 0 {name=x678}
C {openDVS_pixel2x2_top.sym} 2380 11450 0 0 {name=x679}
C {openDVS_pixel2x2_top.sym} 2720 11450 0 0 {name=x680}
C {openDVS_pixel2x2_top.sym} 3060 11450 0 0 {name=x681}
C {openDVS_pixel2x2_top.sym} 3400 11450 0 0 {name=x682}
C {openDVS_pixel2x2_top.sym} 3740 11450 0 0 {name=x683}
C {openDVS_pixel2x2_top.sym} 4080 11450 0 0 {name=x684}
C {openDVS_pixel2x2_top.sym} 4420 11450 0 0 {name=x685}
C {openDVS_pixel2x2_top.sym} 4760 11450 0 0 {name=x686}
C {openDVS_pixel2x2_top.sym} 5100 11450 0 0 {name=x687}
C {openDVS_pixel2x2_top.sym} 5440 11450 0 0 {name=x688}
C {openDVS_pixel2x2_top.sym} 5780 11450 0 0 {name=x689}
C {openDVS_pixel2x2_top.sym} 6120 11450 0 0 {name=x690}
C {openDVS_pixel2x2_top.sym} 6460 11450 0 0 {name=x691}
C {openDVS_pixel2x2_top.sym} 6800 11450 0 0 {name=x692}
C {openDVS_pixel2x2_top.sym} 7140 11450 0 0 {name=x693}
C {openDVS_pixel2x2_top.sym} 7480 11450 0 0 {name=x694}
C {openDVS_pixel2x2_top.sym} 7820 11450 0 0 {name=x695}
C {openDVS_pixel2x2_top.sym} 8160 11450 0 0 {name=x696}
C {openDVS_pixel2x2_top.sym} 8500 11450 0 0 {name=x697}
C {openDVS_pixel2x2_top.sym} 8840 11450 0 0 {name=x698}
C {openDVS_pixel2x2_top.sym} 9180 11450 0 0 {name=x699}
C {openDVS_pixel2x2_top.sym} 9520 11450 0 0 {name=x700}
C {openDVS_pixel2x2_top.sym} 9860 11450 0 0 {name=x701}
C {openDVS_pixel2x2_top.sym} 10200 11450 0 0 {name=x702}
C {openDVS_pixel2x2_top.sym} 10540 11450 0 0 {name=x703}
C {openDVS_pixel2x2_top.sym} 0 11970 0 0 {name=x704}
C {openDVS_pixel2x2_top.sym} 340 11970 0 0 {name=x705}
C {openDVS_pixel2x2_top.sym} 680 11970 0 0 {name=x706}
C {openDVS_pixel2x2_top.sym} 1020 11970 0 0 {name=x707}
C {openDVS_pixel2x2_top.sym} 1360 11970 0 0 {name=x708}
C {openDVS_pixel2x2_top.sym} 1700 11970 0 0 {name=x709}
C {openDVS_pixel2x2_top.sym} 2040 11970 0 0 {name=x710}
C {openDVS_pixel2x2_top.sym} 2380 11970 0 0 {name=x711}
C {openDVS_pixel2x2_top.sym} 2720 11970 0 0 {name=x712}
C {openDVS_pixel2x2_top.sym} 3060 11970 0 0 {name=x713}
C {openDVS_pixel2x2_top.sym} 3400 11970 0 0 {name=x714}
C {openDVS_pixel2x2_top.sym} 3740 11970 0 0 {name=x715}
C {openDVS_pixel2x2_top.sym} 4080 11970 0 0 {name=x716}
C {openDVS_pixel2x2_top.sym} 4420 11970 0 0 {name=x717}
C {openDVS_pixel2x2_top.sym} 4760 11970 0 0 {name=x718}
C {openDVS_pixel2x2_top.sym} 5100 11970 0 0 {name=x719}
C {openDVS_pixel2x2_top.sym} 5440 11970 0 0 {name=x720}
C {openDVS_pixel2x2_top.sym} 5780 11970 0 0 {name=x721}
C {openDVS_pixel2x2_top.sym} 6120 11970 0 0 {name=x722}
C {openDVS_pixel2x2_top.sym} 6460 11970 0 0 {name=x723}
C {openDVS_pixel2x2_top.sym} 6800 11970 0 0 {name=x724}
C {openDVS_pixel2x2_top.sym} 7140 11970 0 0 {name=x725}
C {openDVS_pixel2x2_top.sym} 7480 11970 0 0 {name=x726}
C {openDVS_pixel2x2_top.sym} 7820 11970 0 0 {name=x727}
C {openDVS_pixel2x2_top.sym} 8160 11970 0 0 {name=x728}
C {openDVS_pixel2x2_top.sym} 8500 11970 0 0 {name=x729}
C {openDVS_pixel2x2_top.sym} 8840 11970 0 0 {name=x730}
C {openDVS_pixel2x2_top.sym} 9180 11970 0 0 {name=x731}
C {openDVS_pixel2x2_top.sym} 9520 11970 0 0 {name=x732}
C {openDVS_pixel2x2_top.sym} 9860 11970 0 0 {name=x733}
C {openDVS_pixel2x2_top.sym} 10200 11970 0 0 {name=x734}
C {openDVS_pixel2x2_top.sym} 10540 11970 0 0 {name=x735}
C {openDVS_pixel2x2_top.sym} 0 12490 0 0 {name=x736}
C {openDVS_pixel2x2_top.sym} 340 12490 0 0 {name=x737}
C {openDVS_pixel2x2_top.sym} 680 12490 0 0 {name=x738}
C {openDVS_pixel2x2_top.sym} 1020 12490 0 0 {name=x739}
C {openDVS_pixel2x2_top.sym} 1360 12490 0 0 {name=x740}
C {openDVS_pixel2x2_top.sym} 1700 12490 0 0 {name=x741}
C {openDVS_pixel2x2_top.sym} 2040 12490 0 0 {name=x742}
C {openDVS_pixel2x2_top.sym} 2380 12490 0 0 {name=x743}
C {openDVS_pixel2x2_top.sym} 2720 12490 0 0 {name=x744}
C {openDVS_pixel2x2_top.sym} 3060 12490 0 0 {name=x745}
C {openDVS_pixel2x2_top.sym} 3400 12490 0 0 {name=x746}
C {openDVS_pixel2x2_top.sym} 3740 12490 0 0 {name=x747}
C {openDVS_pixel2x2_top.sym} 4080 12490 0 0 {name=x748}
C {openDVS_pixel2x2_top.sym} 4420 12490 0 0 {name=x749}
C {openDVS_pixel2x2_top.sym} 4760 12490 0 0 {name=x750}
C {openDVS_pixel2x2_top.sym} 5100 12490 0 0 {name=x751}
C {openDVS_pixel2x2_top.sym} 5440 12490 0 0 {name=x752}
C {openDVS_pixel2x2_top.sym} 5780 12490 0 0 {name=x753}
C {openDVS_pixel2x2_top.sym} 6120 12490 0 0 {name=x754}
C {openDVS_pixel2x2_top.sym} 6460 12490 0 0 {name=x755}
C {openDVS_pixel2x2_top.sym} 6800 12490 0 0 {name=x756}
C {openDVS_pixel2x2_top.sym} 7140 12490 0 0 {name=x757}
C {openDVS_pixel2x2_top.sym} 7480 12490 0 0 {name=x758}
C {openDVS_pixel2x2_top.sym} 7820 12490 0 0 {name=x759}
C {openDVS_pixel2x2_top.sym} 8160 12490 0 0 {name=x760}
C {openDVS_pixel2x2_top.sym} 8500 12490 0 0 {name=x761}
C {openDVS_pixel2x2_top.sym} 8840 12490 0 0 {name=x762}
C {openDVS_pixel2x2_top.sym} 9180 12490 0 0 {name=x763}
C {openDVS_pixel2x2_top.sym} 9520 12490 0 0 {name=x764}
C {openDVS_pixel2x2_top.sym} 9860 12490 0 0 {name=x765}
C {openDVS_pixel2x2_top.sym} 10200 12490 0 0 {name=x766}
C {openDVS_pixel2x2_top.sym} 10540 12490 0 0 {name=x767}
C {openDVS_pixel2x2_top.sym} 0 13010 0 0 {name=x768}
C {openDVS_pixel2x2_top.sym} 340 13010 0 0 {name=x769}
C {openDVS_pixel2x2_top.sym} 680 13010 0 0 {name=x770}
C {openDVS_pixel2x2_top.sym} 1020 13010 0 0 {name=x771}
C {openDVS_pixel2x2_top.sym} 1360 13010 0 0 {name=x772}
C {openDVS_pixel2x2_top.sym} 1700 13010 0 0 {name=x773}
C {openDVS_pixel2x2_top.sym} 2040 13010 0 0 {name=x774}
C {openDVS_pixel2x2_top.sym} 2380 13010 0 0 {name=x775}
C {openDVS_pixel2x2_top.sym} 2720 13010 0 0 {name=x776}
C {openDVS_pixel2x2_top.sym} 3060 13010 0 0 {name=x777}
C {openDVS_pixel2x2_top.sym} 3400 13010 0 0 {name=x778}
C {openDVS_pixel2x2_top.sym} 3740 13010 0 0 {name=x779}
C {openDVS_pixel2x2_top.sym} 4080 13010 0 0 {name=x780}
C {openDVS_pixel2x2_top.sym} 4420 13010 0 0 {name=x781}
C {openDVS_pixel2x2_top.sym} 4760 13010 0 0 {name=x782}
C {openDVS_pixel2x2_top.sym} 5100 13010 0 0 {name=x783}
C {openDVS_pixel2x2_top.sym} 5440 13010 0 0 {name=x784}
C {openDVS_pixel2x2_top.sym} 5780 13010 0 0 {name=x785}
C {openDVS_pixel2x2_top.sym} 6120 13010 0 0 {name=x786}
C {openDVS_pixel2x2_top.sym} 6460 13010 0 0 {name=x787}
C {openDVS_pixel2x2_top.sym} 6800 13010 0 0 {name=x788}
C {openDVS_pixel2x2_top.sym} 7140 13010 0 0 {name=x789}
C {openDVS_pixel2x2_top.sym} 7480 13010 0 0 {name=x790}
C {openDVS_pixel2x2_top.sym} 7820 13010 0 0 {name=x791}
C {openDVS_pixel2x2_top.sym} 8160 13010 0 0 {name=x792}
C {openDVS_pixel2x2_top.sym} 8500 13010 0 0 {name=x793}
C {openDVS_pixel2x2_top.sym} 8840 13010 0 0 {name=x794}
C {openDVS_pixel2x2_top.sym} 9180 13010 0 0 {name=x795}
C {openDVS_pixel2x2_top.sym} 9520 13010 0 0 {name=x796}
C {openDVS_pixel2x2_top.sym} 9860 13010 0 0 {name=x797}
C {openDVS_pixel2x2_top.sym} 10200 13010 0 0 {name=x798}
C {openDVS_pixel2x2_top.sym} 10540 13010 0 0 {name=x799}
C {openDVS_pixel2x2_top.sym} 0 13530 0 0 {name=x800}
C {openDVS_pixel2x2_top.sym} 340 13530 0 0 {name=x801}
C {openDVS_pixel2x2_top.sym} 680 13530 0 0 {name=x802}
C {openDVS_pixel2x2_top.sym} 1020 13530 0 0 {name=x803}
C {openDVS_pixel2x2_top.sym} 1360 13530 0 0 {name=x804}
C {openDVS_pixel2x2_top.sym} 1700 13530 0 0 {name=x805}
C {openDVS_pixel2x2_top.sym} 2040 13530 0 0 {name=x806}
C {openDVS_pixel2x2_top.sym} 2380 13530 0 0 {name=x807}
C {openDVS_pixel2x2_top.sym} 2720 13530 0 0 {name=x808}
C {openDVS_pixel2x2_top.sym} 3060 13530 0 0 {name=x809}
C {openDVS_pixel2x2_top.sym} 3400 13530 0 0 {name=x810}
C {openDVS_pixel2x2_top.sym} 3740 13530 0 0 {name=x811}
C {openDVS_pixel2x2_top.sym} 4080 13530 0 0 {name=x812}
C {openDVS_pixel2x2_top.sym} 4420 13530 0 0 {name=x813}
C {openDVS_pixel2x2_top.sym} 4760 13530 0 0 {name=x814}
C {openDVS_pixel2x2_top.sym} 5100 13530 0 0 {name=x815}
C {openDVS_pixel2x2_top.sym} 5440 13530 0 0 {name=x816}
C {openDVS_pixel2x2_top.sym} 5780 13530 0 0 {name=x817}
C {openDVS_pixel2x2_top.sym} 6120 13530 0 0 {name=x818}
C {openDVS_pixel2x2_top.sym} 6460 13530 0 0 {name=x819}
C {openDVS_pixel2x2_top.sym} 6800 13530 0 0 {name=x820}
C {openDVS_pixel2x2_top.sym} 7140 13530 0 0 {name=x821}
C {openDVS_pixel2x2_top.sym} 7480 13530 0 0 {name=x822}
C {openDVS_pixel2x2_top.sym} 7820 13530 0 0 {name=x823}
C {openDVS_pixel2x2_top.sym} 8160 13530 0 0 {name=x824}
C {openDVS_pixel2x2_top.sym} 8500 13530 0 0 {name=x825}
C {openDVS_pixel2x2_top.sym} 8840 13530 0 0 {name=x826}
C {openDVS_pixel2x2_top.sym} 9180 13530 0 0 {name=x827}
C {openDVS_pixel2x2_top.sym} 9520 13530 0 0 {name=x828}
C {openDVS_pixel2x2_top.sym} 9860 13530 0 0 {name=x829}
C {openDVS_pixel2x2_top.sym} 10200 13530 0 0 {name=x830}
C {openDVS_pixel2x2_top.sym} 10540 13530 0 0 {name=x831}
C {openDVS_pixel2x2_top.sym} 0 14050 0 0 {name=x832}
C {openDVS_pixel2x2_top.sym} 340 14050 0 0 {name=x833}
C {openDVS_pixel2x2_top.sym} 680 14050 0 0 {name=x834}
C {openDVS_pixel2x2_top.sym} 1020 14050 0 0 {name=x835}
C {openDVS_pixel2x2_top.sym} 1360 14050 0 0 {name=x836}
C {openDVS_pixel2x2_top.sym} 1700 14050 0 0 {name=x837}
C {openDVS_pixel2x2_top.sym} 2040 14050 0 0 {name=x838}
C {openDVS_pixel2x2_top.sym} 2380 14050 0 0 {name=x839}
C {openDVS_pixel2x2_top.sym} 2720 14050 0 0 {name=x840}
C {openDVS_pixel2x2_top.sym} 3060 14050 0 0 {name=x841}
C {openDVS_pixel2x2_top.sym} 3400 14050 0 0 {name=x842}
C {openDVS_pixel2x2_top.sym} 3740 14050 0 0 {name=x843}
C {openDVS_pixel2x2_top.sym} 4080 14050 0 0 {name=x844}
C {openDVS_pixel2x2_top.sym} 4420 14050 0 0 {name=x845}
C {openDVS_pixel2x2_top.sym} 4760 14050 0 0 {name=x846}
C {openDVS_pixel2x2_top.sym} 5100 14050 0 0 {name=x847}
C {openDVS_pixel2x2_top.sym} 5440 14050 0 0 {name=x848}
C {openDVS_pixel2x2_top.sym} 5780 14050 0 0 {name=x849}
C {openDVS_pixel2x2_top.sym} 6120 14050 0 0 {name=x850}
C {openDVS_pixel2x2_top.sym} 6460 14050 0 0 {name=x851}
C {openDVS_pixel2x2_top.sym} 6800 14050 0 0 {name=x852}
C {openDVS_pixel2x2_top.sym} 7140 14050 0 0 {name=x853}
C {openDVS_pixel2x2_top.sym} 7480 14050 0 0 {name=x854}
C {openDVS_pixel2x2_top.sym} 7820 14050 0 0 {name=x855}
C {openDVS_pixel2x2_top.sym} 8160 14050 0 0 {name=x856}
C {openDVS_pixel2x2_top.sym} 8500 14050 0 0 {name=x857}
C {openDVS_pixel2x2_top.sym} 8840 14050 0 0 {name=x858}
C {openDVS_pixel2x2_top.sym} 9180 14050 0 0 {name=x859}
C {openDVS_pixel2x2_top.sym} 9520 14050 0 0 {name=x860}
C {openDVS_pixel2x2_top.sym} 9860 14050 0 0 {name=x861}
C {openDVS_pixel2x2_top.sym} 10200 14050 0 0 {name=x862}
C {openDVS_pixel2x2_top.sym} 10540 14050 0 0 {name=x863}
C {openDVS_pixel2x2_top.sym} 0 14570 0 0 {name=x864}
C {openDVS_pixel2x2_top.sym} 340 14570 0 0 {name=x865}
C {openDVS_pixel2x2_top.sym} 680 14570 0 0 {name=x866}
C {openDVS_pixel2x2_top.sym} 1020 14570 0 0 {name=x867}
C {openDVS_pixel2x2_top.sym} 1360 14570 0 0 {name=x868}
C {openDVS_pixel2x2_top.sym} 1700 14570 0 0 {name=x869}
C {openDVS_pixel2x2_top.sym} 2040 14570 0 0 {name=x870}
C {openDVS_pixel2x2_top.sym} 2380 14570 0 0 {name=x871}
C {openDVS_pixel2x2_top.sym} 2720 14570 0 0 {name=x872}
C {openDVS_pixel2x2_top.sym} 3060 14570 0 0 {name=x873}
C {openDVS_pixel2x2_top.sym} 3400 14570 0 0 {name=x874}
C {openDVS_pixel2x2_top.sym} 3740 14570 0 0 {name=x875}
C {openDVS_pixel2x2_top.sym} 4080 14570 0 0 {name=x876}
C {openDVS_pixel2x2_top.sym} 4420 14570 0 0 {name=x877}
C {openDVS_pixel2x2_top.sym} 4760 14570 0 0 {name=x878}
C {openDVS_pixel2x2_top.sym} 5100 14570 0 0 {name=x879}
C {openDVS_pixel2x2_top.sym} 5440 14570 0 0 {name=x880}
C {openDVS_pixel2x2_top.sym} 5780 14570 0 0 {name=x881}
C {openDVS_pixel2x2_top.sym} 6120 14570 0 0 {name=x882}
C {openDVS_pixel2x2_top.sym} 6460 14570 0 0 {name=x883}
C {openDVS_pixel2x2_top.sym} 6800 14570 0 0 {name=x884}
C {openDVS_pixel2x2_top.sym} 7140 14570 0 0 {name=x885}
C {openDVS_pixel2x2_top.sym} 7480 14570 0 0 {name=x886}
C {openDVS_pixel2x2_top.sym} 7820 14570 0 0 {name=x887}
C {openDVS_pixel2x2_top.sym} 8160 14570 0 0 {name=x888}
C {openDVS_pixel2x2_top.sym} 8500 14570 0 0 {name=x889}
C {openDVS_pixel2x2_top.sym} 8840 14570 0 0 {name=x890}
C {openDVS_pixel2x2_top.sym} 9180 14570 0 0 {name=x891}
C {openDVS_pixel2x2_top.sym} 9520 14570 0 0 {name=x892}
C {openDVS_pixel2x2_top.sym} 9860 14570 0 0 {name=x893}
C {openDVS_pixel2x2_top.sym} 10200 14570 0 0 {name=x894}
C {openDVS_pixel2x2_top.sym} 10540 14570 0 0 {name=x895}
C {openDVS_pixel2x2_top.sym} 0 15090 0 0 {name=x896}
C {openDVS_pixel2x2_top.sym} 340 15090 0 0 {name=x897}
C {openDVS_pixel2x2_top.sym} 680 15090 0 0 {name=x898}
C {openDVS_pixel2x2_top.sym} 1020 15090 0 0 {name=x899}
C {openDVS_pixel2x2_top.sym} 1360 15090 0 0 {name=x900}
C {openDVS_pixel2x2_top.sym} 1700 15090 0 0 {name=x901}
C {openDVS_pixel2x2_top.sym} 2040 15090 0 0 {name=x902}
C {openDVS_pixel2x2_top.sym} 2380 15090 0 0 {name=x903}
C {openDVS_pixel2x2_top.sym} 2720 15090 0 0 {name=x904}
C {openDVS_pixel2x2_top.sym} 3060 15090 0 0 {name=x905}
C {openDVS_pixel2x2_top.sym} 3400 15090 0 0 {name=x906}
C {openDVS_pixel2x2_top.sym} 3740 15090 0 0 {name=x907}
C {openDVS_pixel2x2_top.sym} 4080 15090 0 0 {name=x908}
C {openDVS_pixel2x2_top.sym} 4420 15090 0 0 {name=x909}
C {openDVS_pixel2x2_top.sym} 4760 15090 0 0 {name=x910}
C {openDVS_pixel2x2_top.sym} 5100 15090 0 0 {name=x911}
C {openDVS_pixel2x2_top.sym} 5440 15090 0 0 {name=x912}
C {openDVS_pixel2x2_top.sym} 5780 15090 0 0 {name=x913}
C {openDVS_pixel2x2_top.sym} 6120 15090 0 0 {name=x914}
C {openDVS_pixel2x2_top.sym} 6460 15090 0 0 {name=x915}
C {openDVS_pixel2x2_top.sym} 6800 15090 0 0 {name=x916}
C {openDVS_pixel2x2_top.sym} 7140 15090 0 0 {name=x917}
C {openDVS_pixel2x2_top.sym} 7480 15090 0 0 {name=x918}
C {openDVS_pixel2x2_top.sym} 7820 15090 0 0 {name=x919}
C {openDVS_pixel2x2_top.sym} 8160 15090 0 0 {name=x920}
C {openDVS_pixel2x2_top.sym} 8500 15090 0 0 {name=x921}
C {openDVS_pixel2x2_top.sym} 8840 15090 0 0 {name=x922}
C {openDVS_pixel2x2_top.sym} 9180 15090 0 0 {name=x923}
C {openDVS_pixel2x2_top.sym} 9520 15090 0 0 {name=x924}
C {openDVS_pixel2x2_top.sym} 9860 15090 0 0 {name=x925}
C {openDVS_pixel2x2_top.sym} 10200 15090 0 0 {name=x926}
C {openDVS_pixel2x2_top.sym} 10540 15090 0 0 {name=x927}
C {openDVS_pixel2x2_top.sym} 0 15610 0 0 {name=x928}
C {openDVS_pixel2x2_top.sym} 340 15610 0 0 {name=x929}
C {openDVS_pixel2x2_top.sym} 680 15610 0 0 {name=x930}
C {openDVS_pixel2x2_top.sym} 1020 15610 0 0 {name=x931}
C {openDVS_pixel2x2_top.sym} 1360 15610 0 0 {name=x932}
C {openDVS_pixel2x2_top.sym} 1700 15610 0 0 {name=x933}
C {openDVS_pixel2x2_top.sym} 2040 15610 0 0 {name=x934}
C {openDVS_pixel2x2_top.sym} 2380 15610 0 0 {name=x935}
C {openDVS_pixel2x2_top.sym} 2720 15610 0 0 {name=x936}
C {openDVS_pixel2x2_top.sym} 3060 15610 0 0 {name=x937}
C {openDVS_pixel2x2_top.sym} 3400 15610 0 0 {name=x938}
C {openDVS_pixel2x2_top.sym} 3740 15610 0 0 {name=x939}
C {openDVS_pixel2x2_top.sym} 4080 15610 0 0 {name=x940}
C {openDVS_pixel2x2_top.sym} 4420 15610 0 0 {name=x941}
C {openDVS_pixel2x2_top.sym} 4760 15610 0 0 {name=x942}
C {openDVS_pixel2x2_top.sym} 5100 15610 0 0 {name=x943}
C {openDVS_pixel2x2_top.sym} 5440 15610 0 0 {name=x944}
C {openDVS_pixel2x2_top.sym} 5780 15610 0 0 {name=x945}
C {openDVS_pixel2x2_top.sym} 6120 15610 0 0 {name=x946}
C {openDVS_pixel2x2_top.sym} 6460 15610 0 0 {name=x947}
C {openDVS_pixel2x2_top.sym} 6800 15610 0 0 {name=x948}
C {openDVS_pixel2x2_top.sym} 7140 15610 0 0 {name=x949}
C {openDVS_pixel2x2_top.sym} 7480 15610 0 0 {name=x950}
C {openDVS_pixel2x2_top.sym} 7820 15610 0 0 {name=x951}
C {openDVS_pixel2x2_top.sym} 8160 15610 0 0 {name=x952}
C {openDVS_pixel2x2_top.sym} 8500 15610 0 0 {name=x953}
C {openDVS_pixel2x2_top.sym} 8840 15610 0 0 {name=x954}
C {openDVS_pixel2x2_top.sym} 9180 15610 0 0 {name=x955}
C {openDVS_pixel2x2_top.sym} 9520 15610 0 0 {name=x956}
C {openDVS_pixel2x2_top.sym} 9860 15610 0 0 {name=x957}
C {openDVS_pixel2x2_top.sym} 10200 15610 0 0 {name=x958}
C {openDVS_pixel2x2_top.sym} 10540 15610 0 0 {name=x959}
C {openDVS_pixel2x2_top.sym} 0 16130 0 0 {name=x960}
C {openDVS_pixel2x2_top.sym} 340 16130 0 0 {name=x961}
C {openDVS_pixel2x2_top.sym} 680 16130 0 0 {name=x962}
C {openDVS_pixel2x2_top.sym} 1020 16130 0 0 {name=x963}
C {openDVS_pixel2x2_top.sym} 1360 16130 0 0 {name=x964}
C {openDVS_pixel2x2_top.sym} 1700 16130 0 0 {name=x965}
C {openDVS_pixel2x2_top.sym} 2040 16130 0 0 {name=x966}
C {openDVS_pixel2x2_top.sym} 2380 16130 0 0 {name=x967}
C {openDVS_pixel2x2_top.sym} 2720 16130 0 0 {name=x968}
C {openDVS_pixel2x2_top.sym} 3060 16130 0 0 {name=x969}
C {openDVS_pixel2x2_top.sym} 3400 16130 0 0 {name=x970}
C {openDVS_pixel2x2_top.sym} 3740 16130 0 0 {name=x971}
C {openDVS_pixel2x2_top.sym} 4080 16130 0 0 {name=x972}
C {openDVS_pixel2x2_top.sym} 4420 16130 0 0 {name=x973}
C {openDVS_pixel2x2_top.sym} 4760 16130 0 0 {name=x974}
C {openDVS_pixel2x2_top.sym} 5100 16130 0 0 {name=x975}
C {openDVS_pixel2x2_top.sym} 5440 16130 0 0 {name=x976}
C {openDVS_pixel2x2_top.sym} 5780 16130 0 0 {name=x977}
C {openDVS_pixel2x2_top.sym} 6120 16130 0 0 {name=x978}
C {openDVS_pixel2x2_top.sym} 6460 16130 0 0 {name=x979}
C {openDVS_pixel2x2_top.sym} 6800 16130 0 0 {name=x980}
C {openDVS_pixel2x2_top.sym} 7140 16130 0 0 {name=x981}
C {openDVS_pixel2x2_top.sym} 7480 16130 0 0 {name=x982}
C {openDVS_pixel2x2_top.sym} 7820 16130 0 0 {name=x983}
C {openDVS_pixel2x2_top.sym} 8160 16130 0 0 {name=x984}
C {openDVS_pixel2x2_top.sym} 8500 16130 0 0 {name=x985}
C {openDVS_pixel2x2_top.sym} 8840 16130 0 0 {name=x986}
C {openDVS_pixel2x2_top.sym} 9180 16130 0 0 {name=x987}
C {openDVS_pixel2x2_top.sym} 9520 16130 0 0 {name=x988}
C {openDVS_pixel2x2_top.sym} 9860 16130 0 0 {name=x989}
C {openDVS_pixel2x2_top.sym} 10200 16130 0 0 {name=x990}
C {openDVS_pixel2x2_top.sym} 10540 16130 0 0 {name=x991}
C {openDVS_pixel2x2_top.sym} 0 16650 0 0 {name=x992}
C {openDVS_pixel2x2_top.sym} 340 16650 0 0 {name=x993}
C {openDVS_pixel2x2_top.sym} 680 16650 0 0 {name=x994}
C {openDVS_pixel2x2_top.sym} 1020 16650 0 0 {name=x995}
C {openDVS_pixel2x2_top.sym} 1360 16650 0 0 {name=x996}
C {openDVS_pixel2x2_top.sym} 1700 16650 0 0 {name=x997}
C {openDVS_pixel2x2_top.sym} 2040 16650 0 0 {name=x998}
C {openDVS_pixel2x2_top.sym} 2380 16650 0 0 {name=x999}
C {openDVS_pixel2x2_top.sym} 2720 16650 0 0 {name=x1000}
C {openDVS_pixel2x2_top.sym} 3060 16650 0 0 {name=x1001}
C {openDVS_pixel2x2_top.sym} 3400 16650 0 0 {name=x1002}
C {openDVS_pixel2x2_top.sym} 3740 16650 0 0 {name=x1003}
C {openDVS_pixel2x2_top.sym} 4080 16650 0 0 {name=x1004}
C {openDVS_pixel2x2_top.sym} 4420 16650 0 0 {name=x1005}
C {openDVS_pixel2x2_top.sym} 4760 16650 0 0 {name=x1006}
C {openDVS_pixel2x2_top.sym} 5100 16650 0 0 {name=x1007}
C {openDVS_pixel2x2_top.sym} 5440 16650 0 0 {name=x1008}
C {openDVS_pixel2x2_top.sym} 5780 16650 0 0 {name=x1009}
C {openDVS_pixel2x2_top.sym} 6120 16650 0 0 {name=x1010}
C {openDVS_pixel2x2_top.sym} 6460 16650 0 0 {name=x1011}
C {openDVS_pixel2x2_top.sym} 6800 16650 0 0 {name=x1012}
C {openDVS_pixel2x2_top.sym} 7140 16650 0 0 {name=x1013}
C {openDVS_pixel2x2_top.sym} 7480 16650 0 0 {name=x1014}
C {openDVS_pixel2x2_top.sym} 7820 16650 0 0 {name=x1015}
C {openDVS_pixel2x2_top.sym} 8160 16650 0 0 {name=x1016}
C {openDVS_pixel2x2_top.sym} 8500 16650 0 0 {name=x1017}
C {openDVS_pixel2x2_top.sym} 8840 16650 0 0 {name=x1018}
C {openDVS_pixel2x2_top.sym} 9180 16650 0 0 {name=x1019}
C {openDVS_pixel2x2_top.sym} 9520 16650 0 0 {name=x1020}
C {openDVS_pixel2x2_top.sym} 9860 16650 0 0 {name=x1021}
C {openDVS_pixel2x2_top.sym} 10200 16650 0 0 {name=x1022}
C {openDVS_pixel2x2_top.sym} 10540 16650 0 0 {name=x1023}
C {iopin.sym} -540 70 0 0 {name=p12 lab=GndD}
C {iopin.sym} -540 100 0 0 {name=p13 lab=VDD}
C {iopin.sym} -540 290 0 0 {name=p57 lab=OffBn}
C {iopin.sym} -540 270 0 0 {name=p58 lab=OnBn}
C {iopin.sym} -540 250 0 0 {name=p59 lab=DiffBn}
C {iopin.sym} -540 230 0 0 {name=p60 lab=RefrBp}
C {iopin.sym} -540 210 0 0 {name=p61 lab=PrSFBp}
C {iopin.sym} -540 190 0 0 {name=p62 lab=PrBp}
C {lab_wire.sym} -210 500 0 0 {name=p3 sig_type=std_logic lab=VDD}
C {lab_wire.sym} -210 520 0 0 {name=p1 sig_type=std_logic lab=GndA}
C {lab_wire.sym} -210 540 0 0 {name=p2 sig_type=std_logic lab=GndD}
C {lab_wire.sym} -210 580 0 0 {name=p4 sig_type=std_logic lab=DiffBn}
C {lab_wire.sym} -210 600 0 0 {name=p5 sig_type=std_logic lab=RefrBp}
C {lab_wire.sym} -210 620 0 0 {name=p6 sig_type=std_logic lab=PrSFBp}
C {lab_wire.sym} -210 640 0 0 {name=p7 sig_type=std_logic lab=OffBn}
C {lab_wire.sym} -210 660 0 0 {name=p8 sig_type=std_logic lab=PrBp}
C {lab_wire.sym} -210 680 0 0 {name=p9 sig_type=std_logic lab=OnBn}
C {lab_wire.sym} -210 1300 0 0 {name=p21 sig_type=std_logic lab=rowReadON[2]}
C {lab_wire.sym} -210 1320 0 0 {name=p22 sig_type=std_logic lab=rowReadOFF[2]}
C {lab_wire.sym} -210 1340 0 0 {name=p23 sig_type=std_logic lab=rowReadON[3]}
C {lab_wire.sym} -210 1360 0 0 {name=p24 sig_type=std_logic lab=rowReadOFF[3]}
C {lab_wire.sym} -210 1820 0 0 {name=p25 sig_type=std_logic lab=rowReadON[4]}
C {lab_wire.sym} -210 1840 0 0 {name=p26 sig_type=std_logic lab=rowReadOFF[4]}
C {lab_wire.sym} -210 1860 0 0 {name=p27 sig_type=std_logic lab=rowReadON[5]}
C {lab_wire.sym} -210 1880 0 0 {name=p28 sig_type=std_logic lab=rowReadOFF[5]}
C {lab_wire.sym} -210 2340 0 0 {name=p29 sig_type=std_logic lab=rowReadON[6]}
C {lab_wire.sym} -210 2360 0 0 {name=p30 sig_type=std_logic lab=rowReadOFF[6]}
C {lab_wire.sym} -210 2380 0 0 {name=p31 sig_type=std_logic lab=rowReadON[7]}
C {lab_wire.sym} -210 2400 0 0 {name=p32 sig_type=std_logic lab=rowReadOFF[7]}
C {lab_wire.sym} -210 2860 0 0 {name=p33 sig_type=std_logic lab=rowReadON[8]}
C {lab_wire.sym} -210 2880 0 0 {name=p34 sig_type=std_logic lab=rowReadOFF[8]}
C {lab_wire.sym} -210 2900 0 0 {name=p35 sig_type=std_logic lab=rowReadON[9]}
C {lab_wire.sym} -210 2920 0 0 {name=p36 sig_type=std_logic lab=rowReadOFF[9]}
C {lab_wire.sym} -210 3380 0 0 {name=p37 sig_type=std_logic lab=rowReadON[10]}
C {lab_wire.sym} -210 3400 0 0 {name=p38 sig_type=std_logic lab=rowReadOFF[10]}
C {lab_wire.sym} -210 3420 0 0 {name=p39 sig_type=std_logic lab=rowReadON[11]}
C {lab_wire.sym} -210 3440 0 0 {name=p40 sig_type=std_logic lab=rowReadOFF[11]}
C {lab_wire.sym} -210 3900 0 0 {name=p41 sig_type=std_logic lab=rowReadON[12]}
C {lab_wire.sym} -210 3920 0 0 {name=p42 sig_type=std_logic lab=rowReadOFF[12]}
C {lab_wire.sym} -210 3940 0 0 {name=p43 sig_type=std_logic lab=rowReadON[13]}
C {lab_wire.sym} -210 3960 0 0 {name=p44 sig_type=std_logic lab=rowReadOFF[13]}
C {lab_wire.sym} -210 4420 0 0 {name=p45 sig_type=std_logic lab=rowReadON[14]}
C {lab_wire.sym} -210 4440 0 0 {name=p46 sig_type=std_logic lab=rowReadOFF[14]}
C {lab_wire.sym} -210 4460 0 0 {name=p47 sig_type=std_logic lab=rowReadON[15]}
C {lab_wire.sym} -210 4480 0 0 {name=p48 sig_type=std_logic lab=rowReadOFF[15]}
C {lab_wire.sym} -210 4940 0 0 {name=p49 sig_type=std_logic lab=rowReadON[16]}
C {lab_wire.sym} -210 4960 0 0 {name=p50 sig_type=std_logic lab=rowReadOFF[16]}
C {lab_wire.sym} -210 4980 0 0 {name=p51 sig_type=std_logic lab=rowReadON[17]}
C {lab_wire.sym} -210 5000 0 0 {name=p52 sig_type=std_logic lab=rowReadOFF[17]}
C {lab_wire.sym} -210 5460 0 0 {name=p53 sig_type=std_logic lab=rowReadON[18]}
C {lab_wire.sym} -210 5480 0 0 {name=p54 sig_type=std_logic lab=rowReadOFF[18]}
C {lab_wire.sym} -210 5500 0 0 {name=p55 sig_type=std_logic lab=rowReadON[19]}
C {lab_wire.sym} -210 5520 0 0 {name=p56 sig_type=std_logic lab=rowReadOFF[19]}
C {lab_wire.sym} -210 5980 0 0 {name=p63 sig_type=std_logic lab=rowReadON[20]}
C {lab_wire.sym} -210 6000 0 0 {name=p64 sig_type=std_logic lab=rowReadOFF[20]}
C {lab_wire.sym} -210 6020 0 0 {name=p65 sig_type=std_logic lab=rowReadON[21]}
C {lab_wire.sym} -210 6040 0 0 {name=p66 sig_type=std_logic lab=rowReadOFF[21]}
C {lab_wire.sym} -210 6500 0 0 {name=p67 sig_type=std_logic lab=rowReadON[22]}
C {lab_wire.sym} -210 6520 0 0 {name=p68 sig_type=std_logic lab=rowReadOFF[22]}
C {lab_wire.sym} -210 6540 0 0 {name=p69 sig_type=std_logic lab=rowReadON[23]}
C {lab_wire.sym} -210 6560 0 0 {name=p70 sig_type=std_logic lab=rowReadOFF[23]}
C {lab_wire.sym} -210 7020 0 0 {name=p71 sig_type=std_logic lab=rowReadON[24]}
C {lab_wire.sym} -210 7040 0 0 {name=p72 sig_type=std_logic lab=rowReadOFF[24]}
C {lab_wire.sym} -210 7060 0 0 {name=p73 sig_type=std_logic lab=rowReadON[25]}
C {lab_wire.sym} -210 7080 0 0 {name=p74 sig_type=std_logic lab=rowReadOFF[25]}
C {lab_wire.sym} -210 7540 0 0 {name=p75 sig_type=std_logic lab=rowReadON[26]}
C {lab_wire.sym} -210 7560 0 0 {name=p76 sig_type=std_logic lab=rowReadOFF[26]}
C {lab_wire.sym} -210 7580 0 0 {name=p77 sig_type=std_logic lab=rowReadON[27]}
C {lab_wire.sym} -210 7600 0 0 {name=p78 sig_type=std_logic lab=rowReadOFF[27]}
C {lab_wire.sym} -210 8060 0 0 {name=p79 sig_type=std_logic lab=rowReadON[28]}
C {lab_wire.sym} -210 8080 0 0 {name=p80 sig_type=std_logic lab=rowReadOFF[28]}
C {lab_wire.sym} -210 8100 0 0 {name=p81 sig_type=std_logic lab=rowReadON[29]}
C {lab_wire.sym} -210 8120 0 0 {name=p82 sig_type=std_logic lab=rowReadOFF[29]}
C {lab_wire.sym} -210 8580 0 0 {name=p83 sig_type=std_logic lab=rowReadON[30]}
C {lab_wire.sym} -210 8600 0 0 {name=p84 sig_type=std_logic lab=rowReadOFF[30]}
C {lab_wire.sym} -210 8620 0 0 {name=p85 sig_type=std_logic lab=rowReadON[31]}
C {lab_wire.sym} -210 8640 0 0 {name=p86 sig_type=std_logic lab=rowReadOFF[31]}
C {lab_wire.sym} -210 9100 0 0 {name=p87 sig_type=std_logic lab=rowReadON[32]}
C {lab_wire.sym} -210 9120 0 0 {name=p88 sig_type=std_logic lab=rowReadOFF[32]}
C {lab_wire.sym} -210 9140 0 0 {name=p89 sig_type=std_logic lab=rowReadON[33]}
C {lab_wire.sym} -210 9160 0 0 {name=p90 sig_type=std_logic lab=rowReadOFF[33]}
C {lab_wire.sym} -210 9620 0 0 {name=p91 sig_type=std_logic lab=rowReadON[34]}
C {lab_wire.sym} -210 9640 0 0 {name=p92 sig_type=std_logic lab=rowReadOFF[34]}
C {lab_wire.sym} -210 9660 0 0 {name=p93 sig_type=std_logic lab=rowReadON[35]}
C {lab_wire.sym} -210 9680 0 0 {name=p94 sig_type=std_logic lab=rowReadOFF[35]}
C {lab_wire.sym} -210 10140 0 0 {name=p95 sig_type=std_logic lab=rowReadON[36]}
C {lab_wire.sym} -210 10160 0 0 {name=p96 sig_type=std_logic lab=rowReadOFF[36]}
C {lab_wire.sym} -210 10180 0 0 {name=p97 sig_type=std_logic lab=rowReadON[37]}
C {lab_wire.sym} -210 10200 0 0 {name=p98 sig_type=std_logic lab=rowReadOFF[37]}
C {lab_wire.sym} -210 10660 0 0 {name=p99 sig_type=std_logic lab=rowReadON[38]}
C {lab_wire.sym} -210 10680 0 0 {name=p100 sig_type=std_logic lab=rowReadOFF[38]}
C {lab_wire.sym} -210 10700 0 0 {name=p101 sig_type=std_logic lab=rowReadON[39]}
C {lab_wire.sym} -210 10720 0 0 {name=p102 sig_type=std_logic lab=rowReadOFF[39]}
C {lab_wire.sym} -210 11180 0 0 {name=p103 sig_type=std_logic lab=rowReadON[40]}
C {lab_wire.sym} -210 11200 0 0 {name=p104 sig_type=std_logic lab=rowReadOFF[40]}
C {lab_wire.sym} -210 11220 0 0 {name=p105 sig_type=std_logic lab=rowReadON[41]}
C {lab_wire.sym} -210 11240 0 0 {name=p106 sig_type=std_logic lab=rowReadOFF[41]}
C {lab_wire.sym} -210 11700 0 0 {name=p107 sig_type=std_logic lab=rowReadON[42]}
C {lab_wire.sym} -210 11720 0 0 {name=p108 sig_type=std_logic lab=rowReadOFF[42]}
C {lab_wire.sym} -210 11740 0 0 {name=p109 sig_type=std_logic lab=rowReadON[43]}
C {lab_wire.sym} -210 11760 0 0 {name=p110 sig_type=std_logic lab=rowReadOFF[43]}
C {lab_wire.sym} -210 12220 0 0 {name=p111 sig_type=std_logic lab=rowReadON[44]}
C {lab_wire.sym} -210 12240 0 0 {name=p112 sig_type=std_logic lab=rowReadOFF[44]}
C {lab_wire.sym} -210 12260 0 0 {name=p113 sig_type=std_logic lab=rowReadON[45]}
C {lab_wire.sym} -210 12280 0 0 {name=p114 sig_type=std_logic lab=rowReadOFF[45]}
C {lab_wire.sym} -210 12740 0 0 {name=p115 sig_type=std_logic lab=rowReadON[46]}
C {lab_wire.sym} -210 12760 0 0 {name=p116 sig_type=std_logic lab=rowReadOFF[46]}
C {lab_wire.sym} -210 12780 0 0 {name=p117 sig_type=std_logic lab=rowReadON[47]}
C {lab_wire.sym} -210 12800 0 0 {name=p118 sig_type=std_logic lab=rowReadOFF[47]}
C {lab_wire.sym} -210 13260 0 0 {name=p119 sig_type=std_logic lab=rowReadON[48]}
C {lab_wire.sym} -210 13280 0 0 {name=p120 sig_type=std_logic lab=rowReadOFF[48]}
C {lab_wire.sym} -210 13300 0 0 {name=p121 sig_type=std_logic lab=rowReadON[49]}
C {lab_wire.sym} -210 13320 0 0 {name=p122 sig_type=std_logic lab=rowReadOFF[49]}
C {lab_wire.sym} -210 13780 0 0 {name=p123 sig_type=std_logic lab=rowReadON[50]}
C {lab_wire.sym} -210 13800 0 0 {name=p124 sig_type=std_logic lab=rowReadOFF[50]}
C {lab_wire.sym} -210 13820 0 0 {name=p125 sig_type=std_logic lab=rowReadON[51]}
C {lab_wire.sym} -210 13840 0 0 {name=p126 sig_type=std_logic lab=rowReadOFF[51]}
C {lab_wire.sym} -210 14300 0 0 {name=p127 sig_type=std_logic lab=rowReadON[52]}
C {lab_wire.sym} -210 14320 0 0 {name=p128 sig_type=std_logic lab=rowReadOFF[52]}
C {lab_wire.sym} -210 14340 0 0 {name=p129 sig_type=std_logic lab=rowReadON[53]}
C {lab_wire.sym} -210 14360 0 0 {name=p130 sig_type=std_logic lab=rowReadOFF[53]}
C {lab_wire.sym} -210 14820 0 0 {name=p131 sig_type=std_logic lab=rowReadON[54]}
C {lab_wire.sym} -210 14840 0 0 {name=p132 sig_type=std_logic lab=rowReadOFF[54]}
C {lab_wire.sym} -210 14860 0 0 {name=p133 sig_type=std_logic lab=rowReadON[55]}
C {lab_wire.sym} -210 14880 0 0 {name=p134 sig_type=std_logic lab=rowReadOFF[55]}
C {lab_wire.sym} -210 15340 0 0 {name=p135 sig_type=std_logic lab=rowReadON[56]}
C {lab_wire.sym} -210 15360 0 0 {name=p136 sig_type=std_logic lab=rowReadOFF[56]}
C {lab_wire.sym} -210 15380 0 0 {name=p137 sig_type=std_logic lab=rowReadON[57]}
C {lab_wire.sym} -210 15400 0 0 {name=p138 sig_type=std_logic lab=rowReadOFF[57]}
C {lab_wire.sym} -210 15860 0 0 {name=p139 sig_type=std_logic lab=rowReadON[58]}
C {lab_wire.sym} -210 15880 0 0 {name=p140 sig_type=std_logic lab=rowReadOFF[58]}
C {lab_wire.sym} -210 15900 0 0 {name=p141 sig_type=std_logic lab=rowReadON[59]}
C {lab_wire.sym} -210 15920 0 0 {name=p142 sig_type=std_logic lab=rowReadOFF[59]}
C {lab_wire.sym} -210 16380 0 0 {name=p143 sig_type=std_logic lab=rowReadON[60]}
C {lab_wire.sym} -210 16400 0 0 {name=p144 sig_type=std_logic lab=rowReadOFF[60]}
C {lab_wire.sym} -210 16420 0 0 {name=p145 sig_type=std_logic lab=rowReadON[61]}
C {lab_wire.sym} -210 16440 0 0 {name=p146 sig_type=std_logic lab=rowReadOFF[61]}
C {lab_wire.sym} -210 16900 0 0 {name=p147 sig_type=std_logic lab=rowReadON[62]}
C {lab_wire.sym} -210 16920 0 0 {name=p148 sig_type=std_logic lab=rowReadOFF[62]}
C {lab_wire.sym} -210 16940 0 0 {name=p149 sig_type=std_logic lab=rowReadON[63]}
C {lab_wire.sym} -210 16960 0 0 {name=p150 sig_type=std_logic lab=rowReadOFF[63]}
C {col_amp_2x1.sym} -130 390 0 0 {name=x1088}
C {col_amp_2x1.sym} 210 390 0 0 {name=x1089}
C {col_amp_2x1.sym} 550 390 0 0 {name=x1090}
C {col_amp_2x1.sym} 890 390 0 0 {name=x1091}
C {col_amp_2x1.sym} 1230 390 0 0 {name=x1092}
C {col_amp_2x1.sym} 1570 390 0 0 {name=x1093}
C {col_amp_2x1.sym} 1910 390 0 0 {name=x1094}
C {col_amp_2x1.sym} 2250 390 0 0 {name=x1095}
C {col_amp_2x1.sym} 2590 390 0 0 {name=x1096}
C {col_amp_2x1.sym} 2930 390 0 0 {name=x1097}
C {col_amp_2x1.sym} 3270 390 0 0 {name=x1098}
C {col_amp_2x1.sym} 3610 390 0 0 {name=x1099}
C {col_amp_2x1.sym} 3950 390 0 0 {name=x1100}
C {col_amp_2x1.sym} 4290 390 0 0 {name=x1101}
C {col_amp_2x1.sym} 4630 390 0 0 {name=x1102}
C {col_amp_2x1.sym} 4970 390 0 0 {name=x1103}
C {col_amp_2x1.sym} 5310 390 0 0 {name=x1104}
C {col_amp_2x1.sym} 5650 390 0 0 {name=x1105}
C {col_amp_2x1.sym} 5990 390 0 0 {name=x1106}
C {col_amp_2x1.sym} 6330 390 0 0 {name=x1107}
C {col_amp_2x1.sym} 6670 390 0 0 {name=x1108}
C {col_amp_2x1.sym} 7010 390 0 0 {name=x1109}
C {col_amp_2x1.sym} 7350 390 0 0 {name=x1110}
C {col_amp_2x1.sym} 7690 390 0 0 {name=x1111}
C {col_amp_2x1.sym} 8030 390 0 0 {name=x1112}
C {col_amp_2x1.sym} 8370 390 0 0 {name=x1113}
C {col_amp_2x1.sym} 8710 390 0 0 {name=x1114}
C {col_amp_2x1.sym} 9050 390 0 0 {name=x1115}
C {col_amp_2x1.sym} 9390 390 0 0 {name=x1116}
C {col_amp_2x1.sym} 9730 390 0 0 {name=x1117}
C {col_amp_2x1.sym} 10070 390 0 0 {name=x1118}
C {col_amp_2x1.sym} 10410 390 0 0 {name=x1119}
C {lab_wire.sym} -210 270 0 0 {name=p10 sig_type=std_logic lab=GndA}
C {lab_wire.sym} -210 250 0 0 {name=p11 sig_type=std_logic lab=VDD}
C {lab_wire.sym} -210 230 0 0 {name=p15 sig_type=std_logic lab=NCHARGE}
C {lab_wire.sym} -210 210 0 0 {name=p16 sig_type=std_logic lab=VTHRESH}
C {lab_wire.sym} -210 190 0 0 {name=p151 sig_type=std_logic lab=nDETECT}
C {lab_wire.sym} -210 170 0 0 {name=p152 sig_type=std_logic lab=DETECT}
C {lab_wire.sym} -110 -20 3 0 {name=p153 sig_type=std_logic lab=pixRst[0]}
C {lab_wire.sym} 130 -20 3 0 {name=p154 sig_type=std_logic lab=pixRst[1]}
C {lab_wire.sym} -50 -20 3 0 {name=p155 sig_type=std_logic lab=voutn[0]}
C {lab_wire.sym} 70 -20 3 0 {name=p156 sig_type=std_logic lab=voutn[1]}
C {lab_wire.sym} 230 -20 3 0 {name=p157 sig_type=std_logic lab=pixRst[2]}
C {lab_wire.sym} 470 -20 3 0 {name=p158 sig_type=std_logic lab=pixRst[3]}
C {lab_wire.sym} 290 -20 3 0 {name=p159 sig_type=std_logic lab=voutn[2]}
C {lab_wire.sym} 410 -20 3 0 {name=p160 sig_type=std_logic lab=voutn[3]}
C {lab_wire.sym} 570 -20 3 0 {name=p161 sig_type=std_logic lab=pixRst[4]}
C {lab_wire.sym} 810 -20 3 0 {name=p162 sig_type=std_logic lab=pixRst[5]}
C {lab_wire.sym} 630 -20 3 0 {name=p163 sig_type=std_logic lab=voutn[4]}
C {lab_wire.sym} 750 -20 3 0 {name=p164 sig_type=std_logic lab=voutn[5]}
C {lab_wire.sym} 910 -20 3 0 {name=p165 sig_type=std_logic lab=pixRst[6]}
C {lab_wire.sym} 1150 -20 3 0 {name=p166 sig_type=std_logic lab=pixRst[7]}
C {lab_wire.sym} 970 -20 3 0 {name=p167 sig_type=std_logic lab=voutn[6]}
C {lab_wire.sym} 1090 -20 3 0 {name=p168 sig_type=std_logic lab=voutn[7]}
C {lab_wire.sym} 1250 -20 3 0 {name=p169 sig_type=std_logic lab=pixRst[8]}
C {lab_wire.sym} 1490 -20 3 0 {name=p170 sig_type=std_logic lab=pixRst[9]}
C {lab_wire.sym} 1310 -20 3 0 {name=p171 sig_type=std_logic lab=voutn[8]}
C {lab_wire.sym} 1430 -20 3 0 {name=p172 sig_type=std_logic lab=voutn[9]}
C {lab_wire.sym} 1590 -20 3 0 {name=p173 sig_type=std_logic lab=pixRst[10]}
C {lab_wire.sym} 1830 -20 3 0 {name=p174 sig_type=std_logic lab=pixRst[11]}
C {lab_wire.sym} 1650 -20 3 0 {name=p175 sig_type=std_logic lab=voutn[10]}
C {lab_wire.sym} 1770 -20 3 0 {name=p176 sig_type=std_logic lab=voutn[11]}
C {lab_wire.sym} 1930 -20 3 0 {name=p177 sig_type=std_logic lab=pixRst[12]}
C {lab_wire.sym} 2170 -20 3 0 {name=p178 sig_type=std_logic lab=pixRst[13]}
C {lab_wire.sym} 1990 -20 3 0 {name=p179 sig_type=std_logic lab=voutn[12]}
C {lab_wire.sym} 2110 -20 3 0 {name=p180 sig_type=std_logic lab=voutn[13]}
C {lab_wire.sym} 2270 -20 3 0 {name=p181 sig_type=std_logic lab=pixRst[14]}
C {lab_wire.sym} 2510 -20 3 0 {name=p182 sig_type=std_logic lab=pixRst[15]}
C {lab_wire.sym} 2330 -20 3 0 {name=p183 sig_type=std_logic lab=voutn[14]}
C {lab_wire.sym} 2450 -20 3 0 {name=p184 sig_type=std_logic lab=voutn[15]}
C {lab_wire.sym} 2610 -20 3 0 {name=p185 sig_type=std_logic lab=pixRst[16]}
C {lab_wire.sym} 2850 -20 3 0 {name=p186 sig_type=std_logic lab=pixRst[17]}
C {lab_wire.sym} 2670 -20 3 0 {name=p187 sig_type=std_logic lab=voutn[16]}
C {lab_wire.sym} 2790 -20 3 0 {name=p188 sig_type=std_logic lab=voutn[17]}
C {lab_wire.sym} 2950 -20 3 0 {name=p189 sig_type=std_logic lab=pixRst[18]}
C {lab_wire.sym} 3190 -20 3 0 {name=p190 sig_type=std_logic lab=pixRst[19]}
C {lab_wire.sym} 3010 -20 3 0 {name=p191 sig_type=std_logic lab=voutn[18]}
C {lab_wire.sym} 3130 -20 3 0 {name=p192 sig_type=std_logic lab=voutn[19]}
C {lab_wire.sym} 3290 -20 3 0 {name=p193 sig_type=std_logic lab=pixRst[20]}
C {lab_wire.sym} 3530 -20 3 0 {name=p194 sig_type=std_logic lab=pixRst[21]}
C {lab_wire.sym} 3350 -20 3 0 {name=p195 sig_type=std_logic lab=voutn[20]}
C {lab_wire.sym} 3470 -20 3 0 {name=p196 sig_type=std_logic lab=voutn[21]}
C {lab_wire.sym} 3630 -20 3 0 {name=p197 sig_type=std_logic lab=pixRst[22]}
C {lab_wire.sym} 3870 -20 3 0 {name=p198 sig_type=std_logic lab=pixRst[23]}
C {lab_wire.sym} 3690 -20 3 0 {name=p199 sig_type=std_logic lab=voutn[22]}
C {lab_wire.sym} 3810 -20 3 0 {name=p200 sig_type=std_logic lab=voutn[23]}
C {lab_wire.sym} 3970 -20 3 0 {name=p201 sig_type=std_logic lab=pixRst[24]}
C {lab_wire.sym} 4210 -20 3 0 {name=p202 sig_type=std_logic lab=pixRst[25]}
C {lab_wire.sym} 4030 -20 3 0 {name=p203 sig_type=std_logic lab=voutn[24]}
C {lab_wire.sym} 4150 -20 3 0 {name=p204 sig_type=std_logic lab=voutn[25]}
C {lab_wire.sym} 4310 -20 3 0 {name=p205 sig_type=std_logic lab=pixRst[26]}
C {lab_wire.sym} 4550 -20 3 0 {name=p206 sig_type=std_logic lab=pixRst[27]}
C {lab_wire.sym} 4370 -20 3 0 {name=p207 sig_type=std_logic lab=voutn[26]}
C {lab_wire.sym} 4490 -20 3 0 {name=p208 sig_type=std_logic lab=voutn[27]}
C {lab_wire.sym} 4650 -20 3 0 {name=p209 sig_type=std_logic lab=pixRst[28]}
C {lab_wire.sym} 4890 -20 3 0 {name=p210 sig_type=std_logic lab=pixRst[29]}
C {lab_wire.sym} 4710 -20 3 0 {name=p211 sig_type=std_logic lab=voutn[28]}
C {lab_wire.sym} 4830 -20 3 0 {name=p212 sig_type=std_logic lab=voutn[29]}
C {lab_wire.sym} 4990 -20 3 0 {name=p213 sig_type=std_logic lab=pixRst[30]}
C {lab_wire.sym} 5230 -20 3 0 {name=p214 sig_type=std_logic lab=pixRst[31]}
C {lab_wire.sym} 5050 -20 3 0 {name=p215 sig_type=std_logic lab=voutn[30]}
C {lab_wire.sym} 5170 -20 3 0 {name=p216 sig_type=std_logic lab=voutn[31]}
C {lab_wire.sym} 5330 -20 3 0 {name=p217 sig_type=std_logic lab=pixRst[32]}
C {lab_wire.sym} 5570 -20 3 0 {name=p218 sig_type=std_logic lab=pixRst[33]}
C {lab_wire.sym} 5390 -20 3 0 {name=p219 sig_type=std_logic lab=voutn[32]}
C {lab_wire.sym} 5510 -20 3 0 {name=p220 sig_type=std_logic lab=voutn[33]}
C {lab_wire.sym} 5670 -20 3 0 {name=p221 sig_type=std_logic lab=pixRst[34]}
C {lab_wire.sym} 5910 -20 3 0 {name=p222 sig_type=std_logic lab=pixRst[35]}
C {lab_wire.sym} 5730 -20 3 0 {name=p223 sig_type=std_logic lab=voutn[34]}
C {lab_wire.sym} 5850 -20 3 0 {name=p224 sig_type=std_logic lab=voutn[35]}
C {lab_wire.sym} 6010 -20 3 0 {name=p225 sig_type=std_logic lab=pixRst[36]}
C {lab_wire.sym} 6250 -20 3 0 {name=p226 sig_type=std_logic lab=pixRst[37]}
C {lab_wire.sym} 6070 -20 3 0 {name=p227 sig_type=std_logic lab=voutn[36]}
C {lab_wire.sym} 6190 -20 3 0 {name=p228 sig_type=std_logic lab=voutn[37]}
C {lab_wire.sym} 6350 -20 3 0 {name=p229 sig_type=std_logic lab=pixRst[38]}
C {lab_wire.sym} 6590 -20 3 0 {name=p230 sig_type=std_logic lab=pixRst[39]}
C {lab_wire.sym} 6410 -20 3 0 {name=p231 sig_type=std_logic lab=voutn[38]}
C {lab_wire.sym} 6530 -20 3 0 {name=p232 sig_type=std_logic lab=voutn[39]}
C {lab_wire.sym} 6690 -20 3 0 {name=p233 sig_type=std_logic lab=pixRst[40]}
C {lab_wire.sym} 6930 -20 3 0 {name=p234 sig_type=std_logic lab=pixRst[41]}
C {lab_wire.sym} 6750 -20 3 0 {name=p235 sig_type=std_logic lab=voutn[40]}
C {lab_wire.sym} 6870 -20 3 0 {name=p236 sig_type=std_logic lab=voutn[41]}
C {lab_wire.sym} 7030 -20 3 0 {name=p237 sig_type=std_logic lab=pixRst[42]}
C {lab_wire.sym} 7270 -20 3 0 {name=p238 sig_type=std_logic lab=pixRst[43]}
C {lab_wire.sym} 7090 -20 3 0 {name=p239 sig_type=std_logic lab=voutn[42]}
C {lab_wire.sym} 7210 -20 3 0 {name=p240 sig_type=std_logic lab=voutn[43]}
C {lab_wire.sym} 7370 -20 3 0 {name=p241 sig_type=std_logic lab=pixRst[44]}
C {lab_wire.sym} 7610 -20 3 0 {name=p242 sig_type=std_logic lab=pixRst[45]}
C {lab_wire.sym} 7430 -20 3 0 {name=p243 sig_type=std_logic lab=voutn[44]}
C {lab_wire.sym} 7550 -20 3 0 {name=p244 sig_type=std_logic lab=voutn[45]}
C {lab_wire.sym} 7710 -20 3 0 {name=p245 sig_type=std_logic lab=pixRst[46]}
C {lab_wire.sym} 7950 -20 3 0 {name=p246 sig_type=std_logic lab=pixRst[47]}
C {lab_wire.sym} 7770 -20 3 0 {name=p247 sig_type=std_logic lab=voutn[46]}
C {lab_wire.sym} 7890 -20 3 0 {name=p248 sig_type=std_logic lab=voutn[47]}
C {lab_wire.sym} 8050 -20 3 0 {name=p249 sig_type=std_logic lab=pixRst[48]}
C {lab_wire.sym} 8290 -20 3 0 {name=p250 sig_type=std_logic lab=pixRst[49]}
C {lab_wire.sym} 8110 -20 3 0 {name=p251 sig_type=std_logic lab=voutn[48]}
C {lab_wire.sym} 8230 -20 3 0 {name=p252 sig_type=std_logic lab=voutn[49]}
C {lab_wire.sym} 8390 -20 3 0 {name=p253 sig_type=std_logic lab=pixRst[50]}
C {lab_wire.sym} 8630 -20 3 0 {name=p254 sig_type=std_logic lab=pixRst[51]}
C {lab_wire.sym} 8450 -20 3 0 {name=p255 sig_type=std_logic lab=voutn[50]}
C {lab_wire.sym} 8570 -20 3 0 {name=p256 sig_type=std_logic lab=voutn[51]}
C {lab_wire.sym} 8730 -20 3 0 {name=p257 sig_type=std_logic lab=pixRst[52]}
C {lab_wire.sym} 8970 -20 3 0 {name=p258 sig_type=std_logic lab=pixRst[53]}
C {lab_wire.sym} 8790 -20 3 0 {name=p259 sig_type=std_logic lab=voutn[52]}
C {lab_wire.sym} 8910 -20 3 0 {name=p260 sig_type=std_logic lab=voutn[53]}
C {lab_wire.sym} 9070 -20 3 0 {name=p261 sig_type=std_logic lab=pixRst[54]}
C {lab_wire.sym} 9310 -20 3 0 {name=p262 sig_type=std_logic lab=pixRst[55]}
C {lab_wire.sym} 9130 -20 3 0 {name=p263 sig_type=std_logic lab=voutn[54]}
C {lab_wire.sym} 9250 -20 3 0 {name=p264 sig_type=std_logic lab=voutn[55]}
C {lab_wire.sym} 9410 -20 3 0 {name=p265 sig_type=std_logic lab=pixRst[56]}
C {lab_wire.sym} 9650 -20 3 0 {name=p266 sig_type=std_logic lab=pixRst[57]}
C {lab_wire.sym} 9470 -20 3 0 {name=p267 sig_type=std_logic lab=voutn[56]}
C {lab_wire.sym} 9590 -20 3 0 {name=p268 sig_type=std_logic lab=voutn[57]}
C {lab_wire.sym} 9750 -20 3 0 {name=p269 sig_type=std_logic lab=pixRst[58]}
C {lab_wire.sym} 9990 -20 3 0 {name=p270 sig_type=std_logic lab=pixRst[59]}
C {lab_wire.sym} 9810 -20 3 0 {name=p271 sig_type=std_logic lab=voutn[58]}
C {lab_wire.sym} 9930 -20 3 0 {name=p272 sig_type=std_logic lab=voutn[59]}
C {lab_wire.sym} 10090 -20 3 0 {name=p273 sig_type=std_logic lab=pixRst[60]}
C {lab_wire.sym} 10330 -20 3 0 {name=p274 sig_type=std_logic lab=pixRst[61]}
C {lab_wire.sym} 10150 -20 3 0 {name=p275 sig_type=std_logic lab=voutn[60]}
C {lab_wire.sym} 10270 -20 3 0 {name=p276 sig_type=std_logic lab=voutn[61]}
C {lab_wire.sym} 10430 -20 3 0 {name=p277 sig_type=std_logic lab=pixRst[62]}
C {lab_wire.sym} 10670 -20 3 0 {name=p278 sig_type=std_logic lab=pixRst[63]}
C {lab_wire.sym} 10490 -20 3 0 {name=p279 sig_type=std_logic lab=voutn[62]}
C {lab_wire.sym} 10610 -20 3 0 {name=p280 sig_type=std_logic lab=voutn[63]}
C {iopin.sym} -650 70 0 0 {name=p14 lab=NCHARGE}
C {iopin.sym} -650 100 0 0 {name=p281 lab=VTHRESH}
C {iopin.sym} -760 70 0 0 {name=p282 lab=nDETECT}
C {iopin.sym} -760 100 0 0 {name=p283 lab=DETECT}
C {iopin.sym} -760 190 0 0 {name=p284 lab=rowReadON[63:0]}
C {iopin.sym} -760 210 0 0 {name=p285 lab=rowReadOFF[63:0]}
C {iopin.sym} -760 230 0 0 {name=p286 lab=pixRst[63:0]}
C {iopin.sym} -760 250 0 0 {name=p287 lab=voutn[63:0]}
C {lab_wire.sym} -210 780 0 0 {name=p17 sig_type=std_logic lab=rowReadON[0]}
C {lab_wire.sym} -210 800 0 0 {name=p18 sig_type=std_logic lab=rowReadOFF[0]}
C {lab_wire.sym} -210 820 0 0 {name=p19 sig_type=std_logic lab=rowReadON[1]}
C {lab_wire.sym} -210 840 0 0 {name=p20 sig_type=std_logic lab=rowReadOFF[1]}
C {iopin.sym} -540 130 0 0 {name=p288 lab=GndA}
