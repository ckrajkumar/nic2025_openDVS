v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
P 4 1 -710 -260 {}
P 4 1 -710 -240 {}
C {BiasBranchnMasterx11.sym} -30 -20 0 0 {name=x1}
C {lab_wire.sym} 120 -400 0 1 {name=p1 lab=VddA18}
C {lab_wire.sym} 120 -380 0 1 {name=p2 lab=GndA}
C {lab_wire.sym} 120 -360 0 1 {name=p3 lab=BufferN}
C {lab_wire.sym} 120 -340 0 1 {name=p4 lab=BufferP}
C {lab_wire.sym} 120 -320 0 1 {name=p5 lab=VMasterBiasN}
C {lab_wire.sym} 120 -300 0 1 {name=p6 lab=VMasterBiasP}
C {lab_wire.sym} 120 -280 0 1 {name=p7 lab=BiasCB[7:0]}
C {lab_wire.sym} 120 -260 0 1 {name=p8 lab=Bias}
C {lab_wire.sym} -180 -400 0 0 {name=p9 lab=PowerDown}
C {lab_wire.sym} 120 -240 0 1 {name=p10 lab=rx}
C {lab_wire.sym} 120 -220 0 1 {name=p11 lab=PadBias[10:0]}
C {lab_wire.sym} 120 -200 0 1 {name=p12 lab=PadBias[10:0]}
C {lab_wire.sym} -180 -380 0 0 {name=p13 lab=FineCodeBuffer[7:0]}
C {lab_wire.sym} -180 -360 0 0 {name=p14 lab=FineCode_bit[10:0]}
C {lab_wire.sym} -180 -340 0 0 {name=p15 lab=nFineCodeBuffer[7:0]}
C {lab_wire.sym} -180 -320 0 0 {name=p16 lab=FineCode_bit[21:11]}
C {lab_wire.sym} -180 -300 0 0 {name=p17 lab=CoarseOneHotBuffer[7:0]}
C {lab_wire.sym} -180 -280 0 0 {name=p18 lab=LowBiasInterfaceEnBuffer}
C {lab_wire.sym} -180 -260 0 0 {name=p19 lab=FineCode_bit[32:22]}
C {lab_wire.sym} -180 -240 0 0 {name=p20 lab=FineCode_bit[43:33]}
C {lab_wire.sym} -180 -220 0 0 {name=p21 lab=nLowBiasInterfaceEnBuffer}
C {lab_wire.sym} -180 -200 0 0 {name=p22 lab=FineCode_bit[54:44]}
C {lab_wire.sym} -180 -180 0 0 {name=p23 lab=CoarseOneHotLowBiasEnBuffer}
C {lab_wire.sym} -180 -160 0 0 {name=p24 lab=FineCode_bit[65:55]}
C {lab_wire.sym} -180 -140 0 0 {name=p25 lab=FineCode_bit[76:66]}
C {lab_wire.sym} -180 -120 0 0 {name=p26 lab=FineCode_bit[87:77]}
C {lab_wire.sym} -180 -100 0 0 {name=p27 lab=nFineCode_bit[10:0]}
C {lab_wire.sym} -180 -80 0 0 {name=p28 lab=nFineCode_bit[21:11]}
C {lab_wire.sym} -180 -60 0 0 {name=p29 lab=nFineCode_bit[32:22]}
C {lab_wire.sym} -180 -40 0 0 {name=p30 lab=nFineCode_bit[43:33]}
C {lab_wire.sym} -180 -20 0 0 {name=p31 lab=nFineCode_bit[54:44]}
C {lab_wire.sym} -180 0 0 0 {name=p32 lab=nFineCode_bit[65:55]}
C {lab_wire.sym} -180 20 0 0 {name=p33 lab=nFineCode_bit[76:66]}
C {lab_wire.sym} -180 40 0 0 {name=p34 lab=nFineCode_bit[87:77]}
C {lab_wire.sym} -180 60 0 0 {name=p35 lab=CoarseOneHot_bit[10:0]}
C {lab_wire.sym} -180 80 0 0 {name=p36 lab=CoarseOneHot_bit[21:11]}
C {lab_wire.sym} -180 100 0 0 {name=p37 lab=CoarseOneHot_bit[32:22]}
C {lab_wire.sym} -180 120 0 0 {name=p38 lab=CoarseOneHot_bit[43:33]}
C {lab_wire.sym} -180 140 0 0 {name=p39 lab=CoarseOneHot_bit[54:44]}
C {lab_wire.sym} -180 160 0 0 {name=p40 lab=CoarseOneHot_bit[65:55]}
C {lab_wire.sym} -180 180 0 0 {name=p41 lab=CoarseOneHot_bit[76:66]}
C {lab_wire.sym} -180 200 0 0 {name=p42 lab=CoarseOneHot_bit[87:77]}
C {lab_wire.sym} -180 220 0 0 {name=p43 lab=LowBiasInterfaceEn[10:0]}
C {lab_wire.sym} -180 240 0 0 {name=p44 lab=nLowBiasInterfaceEn[10:0]}
C {lab_wire.sym} -180 260 0 0 {name=p45 lab=CoarseOneHotLowBiasEn[10:0]}
C {lab_wire.sym} -180 280 0 0 {name=p46 lab=BIT0[10:0]}
C {lab_wire.sym} -180 300 0 0 {name=p47 lab=PowerDown[10:0]}
C {lab_wire.sym} -180 320 0 0 {name=p48 lab=NBiasEn[10:0]}
C {lab_wire.sym} -180 340 0 0 {name=p49 lab=PBiasEn[10:0]}
C {lab_wire.sym} -180 360 0 0 {name=p50 lab=BiasDisable[10:0]}
C {iopin.sym} -770 -720 0 1 {name=p75 lab=VddA18}
C {iopin.sym} -770 -700 0 1 {name=p76 lab=GndA}
C {opin.sym} -770 -610 2 1 {name=p90 lab=BufferN}
C {opin.sym} -770 -590 2 1 {name=p91 lab=BufferP}
C {iopin.sym} -770 -450 0 1 {name=p92 lab=rx}
C {opin.sym} -770 -570 2 1 {name=p51 lab=VMasterBiasN}
C {opin.sym} -770 -550 2 1 {name=p52 lab=VMasterBiasP}
C {opin.sym} -770 -530 2 1 {name=p53 lab=BiasCB[7:0]}
C {opin.sym} -770 -510 2 1 {name=p54 lab=Bias}
C {ipin.sym} -690 -250 2 1 {name=p55 lab=FineCodeBuffer[7:0]}
C {ipin.sym} -1020 250 2 1 {name=p56 lab=CoarseOneHot_bit[87:0]}
C {ipin.sym} -690 -230 2 1 {name=p57 lab=nFineCodeBuffer[7:0]}
C {ipin.sym} -690 -210 2 1 {name=p58 lab=CoarseOneHotBuffer[7:0]}
C {ipin.sym} -1020 280 2 1 {name=p59 lab=LowBiasInterfaceEn[10:0]}
C {ipin.sym} -1020 300 2 1 {name=p60 lab=nLowBiasInterfaceEn[10:0]}
C {ipin.sym} -1020 320 2 1 {name=p61 lab=CoarseOneHotLowBiasEn[10:0]}
C {ipin.sym} -1020 340 2 1 {name=p62 lab=BIT0[10:0]}
C {ipin.sym} -1020 360 2 1 {name=p63 lab=PowerDown[10:0]}
C {ipin.sym} -690 -190 2 1 {name=p64 lab=LowBiasInterfaceEnBuffer}
C {ipin.sym} -690 -170 2 1 {name=p65 lab=nLowBiasInterfaceEnBuffer}
C {ipin.sym} -690 -150 2 1 {name=p66 lab=CoarseOneHotLowBiasEnBuffer}
C {ipin.sym} -770 -490 2 1 {name=p67 lab=PowerDown}
C {ipin.sym} -1020 380 2 1 {name=p68 lab=NBiasEn[10:0]}
C {ipin.sym} -1020 400 2 1 {name=p69 lab=PBiasEn[10:0]}
C {ipin.sym} -1020 440 2 1 {name=p70 lab=BiasDisable[10:0]}
C {ipin.sym} -1020 -90 2 1 {name=p103 lab=FineCode_bit[87:0]}
C {ipin.sym} -1020 80 2 1 {name=p111 lab=nFineCode_bit[87:0]}
C {iopin.sym} -770 -430 0 1 {name=p71 lab=PadBias[10:0]}
