v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
P 4 1 -300 -510 {}
P 4 1 -300 -490 {}
T {Need to connect to the right rails
according to what we need!} -1050 -1000 0 0 0.5 0.5 {}
T {Need to add decaps
to appropriate rail!} -1070 -880 0 0 0.5 0.5 {}
N 100 -730 100 -670 {lab=VddA18}
N 120 -730 120 -670 {lab=GndA}
N 180 -730 180 -670 {lab=BiasCB[7:0]}
N 280 -730 280 -670 {lab=BufferN}
N 300 -730 300 -670 {lab=BufferP}
N 430 -600 490 -600 {lab=Bias[0]}
N 670 -930 670 -870 {lab=rx}
N 700 -930 700 -870 {lab=BiasCB[0]}
N 730 -930 730 -870 {lab=BiasCB[1]}
N 760 -930 760 -870 {lab=BiasCB[2]}
N 790 -930 790 -870 {lab=BiasCB[3]}
N 820 -930 820 -870 {lab=BiasCB[4]}
N 850 -930 850 -870 {lab=BiasCB[5]}
N 880 -930 880 -870 {lab=BiasCB[6]}
N 910 -930 910 -870 {lab=BiasCB[7]}
N 640 -930 640 -870 {lab=GndA}
N 640 -1170 640 -1110 {lab=VddA18}
N 670 -1170 670 -1110 {lab=PowerDownM}
N 700 -1170 700 -1110 {lab=VMasterBiasN}
N 730 -1170 730 -1110 {lab=VMasterBiasP}
N 100 -1120 100 -1060 {lab=VddA18}
N 120 -1120 120 -1060 {lab=GndA}
N 180 -1120 180 -1060 {lab=BiasCB[7:0]}
N 280 -1120 280 -1060 {lab=BufferN}
N 300 -1120 300 -1060 {lab=BufferP}
N 430 -990 490 -990 {lab=BufferN}
N 430 -1010 490 -1010 {lab=BufferP}
N -160 -950 60 -950 {lab=nFineCodeBuffer[7:0]}
N -160 -890 60 -890 {lab=nLowBiasInterfaceEnBuffer}
N -160 -870 60 -870 {lab=CoarseOneHotLowBiasEnBuffer}
N -160 -970 60 -970 {lab=FineCodeBuffer[7:0]}
N -160 -930 60 -930 {lab=CoarseOneHotBuffer[7:0]}
N -160 -910 60 -910 {lab=LowBiasInterfaceEnBuffer}
N -160 -90 60 -90 {lab=nLowBiasInterfaceEn[0]}
N -160 -70 60 -70 {lab=CoarseOneHotLowBiasEn[0]}
N -160 -110 60 -110 {lab=LowBiasInterfaceEn[0]}
N -160 -30 60 -30 {lab=BIT0[0]}
N -160 -50 60 -50 {lab=PowerDown[0]}
N -160 -10 60 -10 {lab=NBiasEn[0]}
N -160 10 60 10 {lab=PBiasEn[0]}
N -160 50 60 50 {lab=BiasDisabled[0]}
N 430 -500 480 -500 {lab=PadBias[0]}
N 880 -730 880 -670 {lab=VddA18}
N 900 -730 900 -670 {lab=GndA}
N 960 -730 960 -670 {lab=BiasCB[7:0]}
N 1060 -730 1060 -670 {lab=BufferN}
N 1080 -730 1080 -670 {lab=BufferP}
N 1210 -600 1270 -600 {lab=Bias[1]}
N 620 -90 840 -90 {lab=nLowBiasInterfaceEn[1]}
N 620 -70 840 -70 {lab=CoarseOneHotLowBiasEn[1]}
N 620 -110 840 -110 {lab=LowBiasInterfaceEn[1]}
N 620 -30 840 -30 {lab=BIT0[1]}
N 620 -50 840 -50 {lab=PowerDown[1]}
N 620 -10 840 -10 {lab=NBiasEn[1]}
N 620 10 840 10 {lab=PBiasEn[1]}
N 620 50 840 50 {lab=BiasDisabled[1]}
N 1210 -500 1260 -500 {lab=PadBias[1]}
N 1720 -710 1720 -650 {lab=VddA18}
N 1740 -710 1740 -650 {lab=GndA}
N 1800 -710 1800 -650 {lab=BiasCB[7:0]}
N 1900 -710 1900 -650 {lab=BufferN}
N 1920 -710 1920 -650 {lab=BufferP}
N 2050 -580 2110 -580 {lab=Bias[2]}
N 1460 -90 1680 -90 {lab=LowBiasInterfaceEn[2]}
N 1460 -70 1680 -70 {lab=nLowBiasInterfaceEn[2]}
N 1460 -50 1680 -50 {lab=CoarseOneHotLowBiasEn[2]}
N 1460 -30 1680 -30 {lab=PowerDown[2]}
N 1460 -10 1680 -10 {lab=BIT0[2]}
N 1460 10 1680 10 {lab=NBiasEn[2]}
N 1460 30 1680 30 {lab=PBiasEn[2]}
N 1460 70 1680 70 {lab=BiasDisabled[2]}
N 2500 -710 2500 -650 {lab=VddA18}
N 2520 -710 2520 -650 {lab=GndA}
N 2580 -710 2580 -650 {lab=BiasCB[7:0]}
N 2680 -710 2680 -650 {lab=BufferN}
N 2700 -710 2700 -650 {lab=BufferP}
N 2830 -580 2890 -580 {lab=Bias[3]}
N 2240 -90 2460 -90 {lab=LowBiasInterfaceEn[3]}
N 2240 -70 2460 -70 {lab=nLowBiasInterfaceEn[3]}
N 2240 -50 2460 -50 {lab=CoarseOneHotLowBiasEn[3]}
N 2240 -30 2460 -30 {lab=PowerDown[3]}
N 2240 -10 2460 -10 {lab=BIT0[3]}
N 2240 10 2460 10 {lab=NBiasEn[3]}
N 2240 30 2460 30 {lab=PBiasEn[3]}
N 2240 70 2460 70 {lab=BiasDisabled[3]}
N 3340 -690 3340 -630 {lab=VddA18}
N 3360 -690 3360 -630 {lab=GndA}
N 3420 -690 3420 -630 {lab=BiasCB[7:0]}
N 3520 -690 3520 -630 {lab=BufferN}
N 3540 -690 3540 -630 {lab=BufferP}
N 3670 -560 3730 -560 {lab=Bias[4]}
N 3080 -70 3300 -70 {lab=LowBiasInterfaceEn[4]}
N 3080 -50 3300 -50 {lab=nLowBiasInterfaceEn[4]}
N 3080 -30 3300 -30 {lab=CoarseOneHotLowBiasEn[4]}
N 3080 -10 3300 -10 {lab=PowerDown[4]}
N 3080 10 3300 10 {lab=BIT0[4]}
N 3080 30 3300 30 {lab=NBiasEn[4]}
N 3080 50 3300 50 {lab=PBiasEn[4]}
N 3080 90 3300 90 {lab=BiasDisabled[4]}
N 4120 -690 4120 -630 {lab=VddA18}
N 4140 -690 4140 -630 {lab=GndA}
N 4200 -690 4200 -630 {lab=BiasCB[7:0]}
N 4300 -690 4300 -630 {lab=BufferN}
N 4320 -690 4320 -630 {lab=BufferP}
N 4450 -560 4510 -560 {lab=Bias[5]}
N 3860 -70 4080 -70 {lab=LowBiasInterfaceEn[5]}
N 3860 -50 4080 -50 {lab=nLowBiasInterfaceEn[5]}
N 3860 -30 4080 -30 {lab=CoarseOneHotLowBiasEn[5]}
N 3860 -10 4080 -10 {lab=PowerDown[5]}
N 3860 10 4080 10 {lab=BIT0[5]}
N 3860 30 4080 30 {lab=NBiasEn[5]}
N 3860 50 4080 50 {lab=PBiasEn[5]}
N 3860 90 4080 90 {lab=BiasDisabled[5]}
N 4960 -670 4960 -610 {lab=VddA18}
N 4980 -670 4980 -610 {lab=GndA}
N 5040 -670 5040 -610 {lab=BiasCB[7:0]}
N 5140 -670 5140 -610 {lab=BufferN}
N 5160 -670 5160 -610 {lab=BufferP}
N 5290 -540 5350 -540 {lab=Bias[6]}
N 4700 -50 4920 -50 {lab=LowBiasInterfaceEn[6]}
N 4700 -30 4920 -30 {lab=nLowBiasInterfaceEn[6]}
N 4700 -10 4920 -10 {lab=CoarseOneHotLowBiasEn[6]}
N 4700 10 4920 10 {lab=PowerDown[6]}
N 4700 30 4920 30 {lab=BIT0[6]}
N 4700 50 4920 50 {lab=NBiasEn[6]}
N 4700 70 4920 70 {lab=PBiasEn[6]}
N 4700 110 4920 110 {lab=BiasDisabled[6]}
N 5740 -670 5740 -610 {lab=VddA18}
N 5760 -670 5760 -610 {lab=GndA}
N 5820 -670 5820 -610 {lab=BiasCB[7:0]}
N 5920 -670 5920 -610 {lab=BufferN}
N 5940 -670 5940 -610 {lab=BufferP}
N 6070 -540 6130 -540 {lab=Bias[7]}
N 5480 -50 5700 -50 {lab=LowBiasInterfaceEn[7]}
N 5480 -30 5700 -30 {lab=nLowBiasInterfaceEn[7]}
N 5480 -10 5700 -10 {lab=CoarseOneHotLowBiasEn[7]}
N 5480 10 5700 10 {lab=PowerDown[7]}
N 5480 30 5700 30 {lab=BIT0[7]}
N 5480 50 5700 50 {lab=NBiasEn[7]}
N 5480 70 5700 70 {lab=PBiasEn[7]}
N 5480 110 5700 110 {lab=BiasDisabled[7]}
N 6580 -650 6580 -590 {lab=VddA18}
N 6600 -650 6600 -590 {lab=GndA}
N 6660 -650 6660 -590 {lab=BiasCB[7:0]}
N 6760 -650 6760 -590 {lab=BufferN}
N 6780 -650 6780 -590 {lab=BufferP}
N 6910 -520 6970 -520 {lab=Bias[8]}
N 6320 -30 6540 -30 {lab=LowBiasInterfaceEn[8]}
N 6320 -10 6540 -10 {lab=nLowBiasInterfaceEn[8]}
N 6320 10 6540 10 {lab=CoarseOneHotLowBiasEn[8]}
N 6320 30 6540 30 {lab=PowerDown[8]}
N 6320 50 6540 50 {lab=BIT0[8]}
N 6320 70 6540 70 {lab=NBiasEn[8]}
N 6320 90 6540 90 {lab=PBiasEn[8]}
N 6320 130 6540 130 {lab=BiasDisabled[8]}
N 7360 -650 7360 -590 {lab=VddA18}
N 7380 -650 7380 -590 {lab=GndA}
N 7440 -650 7440 -590 {lab=BiasCB[7:0]}
N 7540 -650 7540 -590 {lab=BufferN}
N 7560 -650 7560 -590 {lab=BufferP}
N 7690 -520 7750 -520 {lab=Bias[9]}
N 7100 -30 7320 -30 {lab=LowBiasInterfaceEn[9]}
N 7100 -10 7320 -10 {lab=nLowBiasInterfaceEn[9]}
N 7100 10 7320 10 {lab=CoarseOneHotLowBiasEn[9]}
N 7100 30 7320 30 {lab=PowerDown[9]}
N 7100 50 7320 50 {lab=BIT0[9]}
N 7100 70 7320 70 {lab=NBiasEn[9]}
N 7100 90 7320 90 {lab=PBiasEn[9]}
N 7100 130 7320 130 {lab=BiasDisabled[9]}
N 8200 -630 8200 -570 {lab=VddA18}
N 8220 -630 8220 -570 {lab=GndA}
N 8280 -630 8280 -570 {lab=BiasCB[7:0]}
N 8380 -630 8380 -570 {lab=BufferN}
N 8400 -630 8400 -570 {lab=BufferP}
N 8530 -500 8590 -500 {lab=Bias[10]}
N 7940 -10 8160 -10 {lab=LowBiasInterfaceEn[10]}
N 7940 10 8160 10 {lab=nLowBiasInterfaceEn[10]}
N 7940 30 8160 30 {lab=CoarseOneHotLowBiasEn[10]}
N 7940 50 8160 50 {lab=PowerDown[10]}
N 7940 70 8160 70 {lab=BIT0[10]}
N 7940 90 8160 90 {lab=NBiasEn[10]}
N 7940 110 8160 110 {lab=PBiasEn[10]}
N 7940 150 8160 150 {lab=BiasDisabled[10]}
N 2050 -480 2100 -480 {lab=PadBias[2]}
N 2830 -480 2880 -480 {lab=PadBias[3]}
N 3670 -460 3720 -460 {lab=PadBias[4]}
N 4450 -460 4500 -460 {lab=PadBias[5]}
N 5290 -440 5340 -440 {lab=PadBias[6]}
N 6070 -440 6120 -440 {lab=PadBias[7]}
N 6910 -420 6960 -420 {lab=PadBias[8]}
N 7690 -420 7740 -420 {lab=PadBias[9]}
N 8530 -400 8580 -400 {lab=PadBias[10]}
C {iopin.sym} -360 -970 0 1 {name=p75 lab=VddA18}
C {iopin.sym} -360 -950 0 1 {name=p76 lab=GndA}
C {lab_wire.sym} 100 -730 3 0 {name=p2 sig_type=std_logic lab=VddA18}
C {iopin.sym} -360 -700 0 1 {name=p92 lab=rx}
C {BiasBranch.sym} -100 -540 0 0 {name=xBiasBranch}
C {BiasMasternCoarse.sym} 740 -1020 0 0 {name=xBiasMasternCoarse}
C {lab_wire.sym} 120 -730 3 0 {name=p1 sig_type=std_logic lab=GndA}
C {lab_wire.sym} 180 -730 3 0 {name=p4 sig_type=std_logic lab=BiasCB[7:0]}
C {lab_wire.sym} 280 -730 3 0 {name=p7 sig_type=std_logic lab=BufferN}
C {lab_wire.sym} 300 -730 3 0 {name=p8 sig_type=std_logic lab=BufferP}
C {lab_wire.sym} 670 -870 3 1 {name=p11 sig_type=std_logic lab=rx}
C {lab_wire.sym} 700 -870 3 1 {name=p12 sig_type=std_logic lab=BiasCB[0]}
C {lab_wire.sym} 730 -870 3 1 {name=p13 sig_type=std_logic lab=BiasCB[1]}
C {lab_wire.sym} 760 -870 3 1 {name=p14 sig_type=std_logic lab=BiasCB[2]}
C {lab_wire.sym} 790 -870 3 1 {name=p15 sig_type=std_logic lab=BiasCB[3]}
C {lab_wire.sym} 820 -870 3 1 {name=p16 sig_type=std_logic lab=BiasCB[4]}
C {lab_wire.sym} 850 -870 3 1 {name=p17 sig_type=std_logic lab=BiasCB[5]}
C {lab_wire.sym} 880 -870 3 1 {name=p18 sig_type=std_logic lab=BiasCB[6]}
C {lab_wire.sym} 910 -870 3 1 {name=p19 sig_type=std_logic lab=BiasCB[7]}
C {lab_wire.sym} 640 -870 3 1 {name=p20 sig_type=std_logic lab=GndA}
C {lab_wire.sym} 640 -1170 3 0 {name=p21 sig_type=std_logic lab=VddA18}
C {lab_wire.sym} 670 -1170 3 0 {name=p22 sig_type=std_logic lab=PowerDownM}
C {lab_wire.sym} 700 -1170 3 0 {name=p23 sig_type=std_logic lab=VMasterBiasN}
C {lab_wire.sym} 730 -1170 3 0 {name=p24 sig_type=std_logic lab=VMasterBiasP}
C {BiasBranchBuffer.sym} -100 -930 0 0 {name=xBiasBuffer}
C {lab_wire.sym} 100 -1120 3 0 {name=p5 sig_type=std_logic lab=VddA18}
C {lab_wire.sym} 120 -1120 3 0 {name=p25 sig_type=std_logic lab=GndA}
C {lab_wire.sym} 180 -1120 3 0 {name=p27 sig_type=std_logic lab=BiasCB[7:0]}
C {lab_wire.sym} 280 -1120 3 0 {name=p29 sig_type=std_logic lab=BufferN}
C {lab_wire.sym} 300 -1120 3 0 {name=p30 sig_type=std_logic lab=BufferP}
C {lab_wire.sym} 490 -990 0 0 {name=p31 sig_type=std_logic lab=BufferN}
C {lab_wire.sym} 490 -1010 0 0 {name=p32 sig_type=std_logic lab=BufferP}
C {opin.sym} -360 -760 2 1 {name=p37 lab=Bias[10:0]}
C {lab_wire.sym} 490 -600 0 0 {name=p9 sig_type=std_logic lab=Bias[0]}
C {ipin.sym} -280 -500 2 1 {name=p6 lab=FineCodeBuffer[7:0]}
C {lab_wire.sym} -160 -970 0 1 {name=p33 sig_type=std_logic lab=FineCodeBuffer[7:0]}
C {lab_wire.sym} -160 -950 0 1 {name=p40 sig_type=std_logic lab=nFineCodeBuffer[7:0]}
C {ipin.sym} -280 -480 2 1 {name=p41 lab=nFineCodeBuffer[7:0]}
C {ipin.sym} -280 -460 2 1 {name=p43 lab=CoarseOneHotBuffer[7:0]}
C {iopin.sym} -760 20 2 1 {name=p45 lab=LowBiasInterfaceEn[10:0]}
C {iopin.sym} -760 40 2 1 {name=p46 lab=nLowBiasInterfaceEn[10:0]}
C {iopin.sym} -760 60 2 1 {name=p47 lab=CoarseOneHotLowBiasEn[10:0]}
C {iopin.sym} -760 80 2 1 {name=p48 lab=BIT0[10:0]}
C {iopin.sym} -760 100 2 1 {name=p49 lab=PowerDown[10:0]}
C {ipin.sym} -280 -440 2 1 {name=p50 lab=LowBiasInterfaceEnBuffer}
C {ipin.sym} -280 -420 2 1 {name=p51 lab=nLowBiasInterfaceEnBuffer}
C {ipin.sym} -280 -400 2 1 {name=p52 lab=CoarseOneHotLowBiasEnBuffer}
C {lab_wire.sym} -160 -930 0 1 {name=p53 sig_type=std_logic lab=CoarseOneHotBuffer[7:0]}
C {lab_wire.sym} -160 -910 0 1 {name=p54 sig_type=std_logic lab=LowBiasInterfaceEnBuffer}
C {lab_wire.sym} -160 -890 0 1 {name=p55 sig_type=std_logic lab=nLowBiasInterfaceEnBuffer}
C {lab_wire.sym} -160 -870 0 1 {name=p56 sig_type=std_logic lab=CoarseOneHotLowBiasEnBuffer}
C {lab_wire.sym} -160 -110 0 1 {name=p57 sig_type=std_logic lab=LowBiasInterfaceEn[0]}
C {lab_wire.sym} -160 -90 0 1 {name=p58 sig_type=std_logic lab=nLowBiasInterfaceEn[0]}
C {lab_wire.sym} -160 -70 0 1 {name=p59 sig_type=std_logic lab=CoarseOneHotLowBiasEn[0]}
C {lab_wire.sym} -160 -50 0 1 {name=p61 sig_type=std_logic lab=PowerDown[0]}
C {lab_wire.sym} -160 -30 0 1 {name=p62 sig_type=std_logic lab=BIT0[0]}
C {ipin.sym} -360 -740 2 1 {name=p3 lab=PowerDownM}
C {lab_wire.sym} -160 -10 0 1 {name=p26 sig_type=std_logic lab=NBiasEn[0]}
C {lab_wire.sym} -160 10 0 1 {name=p63 sig_type=std_logic lab=PBiasEn[0]}
C {lab_wire.sym} -160 50 0 1 {name=p65 sig_type=std_logic lab=BiasDisabled[0]}
C {iopin.sym} -760 120 2 1 {name=p66 lab=NBiasEn[10:0]}
C {iopin.sym} -760 140 2 1 {name=p67 lab=PBiasEn[10:0]}
C {iopin.sym} -760 180 2 1 {name=p69 lab=BiasDisabled[10:0]}
C {iopin.sym} -760 -490 2 1 {name=p96 lab=FineCode[87:0]}
C {iopin.sym} -760 -320 2 1 {name=p104 lab=nFineCode[87:0]}
C {iopin.sym} -760 -150 2 1 {name=p112 lab=CoarseOneHot[87:0]}
C {iopin.sym} -360 -680 0 1 {name=p42 lab=PadBias[10:0]}
C {iopin.sym} 480 -500 0 0 {name=p38 lab=PadBias[0]}
C {lab_pin.sym} 60 -590 0 0 {name=p10 lab=FineCode[7]}
C {lab_pin.sym} 60 -570 0 0 {name=p28 lab=FineCode[6]}
C {lab_pin.sym} 60 -550 0 0 {name=p39 lab=FineCode[5]}
C {lab_pin.sym} 60 -530 0 0 {name=p44 lab=FineCode[4]}
C {lab_pin.sym} 60 -510 0 0 {name=p60 lab=FineCode[3]}
C {lab_pin.sym} 60 -490 0 0 {name=p64 lab=FineCode[2]}
C {lab_pin.sym} 60 -470 0 0 {name=p68 lab=FineCode[1]}
C {lab_pin.sym} 60 -450 0 0 {name=p70 lab=FineCode[0]}
C {lab_pin.sym} 60 -430 0 0 {name=p71 lab=nFineCode[7]}
C {lab_pin.sym} 60 -410 0 0 {name=p72 lab=nFineCode[6]}
C {lab_pin.sym} 60 -390 0 0 {name=p73 lab=nFineCode[5]}
C {lab_pin.sym} 60 -370 0 0 {name=p74 lab=nFineCode[4]}
C {lab_pin.sym} 60 -350 0 0 {name=p77 lab=nFineCode[3]}
C {lab_pin.sym} 60 -330 0 0 {name=p79 lab=nFineCode[2]}
C {lab_pin.sym} 60 -310 0 0 {name=p80 lab=nFineCode[1]}
C {lab_pin.sym} 60 -290 0 0 {name=p81 lab=nFineCode[0]}
C {lab_pin.sym} 60 -270 0 0 {name=p82 lab=CoarseOneHot[7]}
C {lab_pin.sym} 60 -250 0 0 {name=p83 lab=CoarseOneHot[6]}
C {lab_pin.sym} 60 -230 0 0 {name=p84 lab=CoarseOneHot[5]}
C {lab_pin.sym} 60 -210 0 0 {name=p85 lab=CoarseOneHot[4]}
C {lab_pin.sym} 60 -190 0 0 {name=p86 lab=CoarseOneHot[3]}
C {lab_pin.sym} 60 -170 0 0 {name=p87 lab=CoarseOneHot[2]}
C {lab_pin.sym} 60 -150 0 0 {name=p88 lab=CoarseOneHot[1]}
C {lab_pin.sym} 60 -130 0 0 {name=p78 lab=CoarseOneHot[0]}
C {lab_wire.sym} 880 -730 3 0 {name=p89 sig_type=std_logic lab=VddA18}
C {BiasBranch.sym} 680 -540 0 0 {name=xBiasBranch1}
C {lab_wire.sym} 900 -730 3 0 {name=p93 sig_type=std_logic lab=GndA}
C {lab_wire.sym} 960 -730 3 0 {name=p94 sig_type=std_logic lab=BiasCB[7:0]}
C {lab_wire.sym} 1060 -730 3 0 {name=p95 sig_type=std_logic lab=BufferN}
C {lab_wire.sym} 1080 -730 3 0 {name=p97 sig_type=std_logic lab=BufferP}
C {lab_wire.sym} 1270 -600 0 0 {name=p98 sig_type=std_logic lab=Bias[1]}
C {lab_wire.sym} 620 -110 0 1 {name=p99 sig_type=std_logic lab=LowBiasInterfaceEn[1]}
C {lab_wire.sym} 620 -90 0 1 {name=p100 sig_type=std_logic lab=nLowBiasInterfaceEn[1]}
C {lab_wire.sym} 620 -70 0 1 {name=p101 sig_type=std_logic lab=CoarseOneHotLowBiasEn[1]}
C {lab_wire.sym} 620 -50 0 1 {name=p102 sig_type=std_logic lab=PowerDown[1]}
C {lab_wire.sym} 620 -30 0 1 {name=p103 sig_type=std_logic lab=BIT0[1]}
C {lab_wire.sym} 620 -10 0 1 {name=p105 sig_type=std_logic lab=NBiasEn[1]}
C {lab_wire.sym} 620 10 0 1 {name=p106 sig_type=std_logic lab=PBiasEn[1]}
C {lab_wire.sym} 620 50 0 1 {name=p107 sig_type=std_logic lab=BiasDisabled[1]}
C {iopin.sym} 1260 -500 0 0 {name=p108 lab=PadBias[1]}
C {lab_pin.sym} 840 -590 0 0 {name=p109 lab=FineCode[15]}
C {lab_pin.sym} 840 -570 0 0 {name=p110 lab=FineCode[14]}
C {lab_pin.sym} 840 -550 0 0 {name=p111 lab=FineCode[13]}
C {lab_pin.sym} 840 -530 0 0 {name=p113 lab=FineCode[12]}
C {lab_pin.sym} 840 -510 0 0 {name=p114 lab=FineCode[11]}
C {lab_pin.sym} 840 -490 0 0 {name=p115 lab=FineCode[10]}
C {lab_pin.sym} 840 -470 0 0 {name=p116 lab=FineCode[9]}
C {lab_pin.sym} 840 -450 0 0 {name=p117 lab=FineCode[8]}
C {lab_pin.sym} 840 -430 0 0 {name=p118 lab=nFineCode[15]}
C {lab_pin.sym} 840 -410 0 0 {name=p119 lab=nFineCode[14]}
C {lab_pin.sym} 840 -390 0 0 {name=p120 lab=nFineCode[13]}
C {lab_pin.sym} 840 -370 0 0 {name=p121 lab=nFineCode[12]}
C {lab_pin.sym} 840 -350 0 0 {name=p122 lab=nFineCode[11]}
C {lab_pin.sym} 840 -330 0 0 {name=p123 lab=nFineCode[10]}
C {lab_pin.sym} 840 -310 0 0 {name=p124 lab=nFineCode[9]}
C {lab_pin.sym} 840 -290 0 0 {name=p125 lab=nFineCode[8]}
C {lab_pin.sym} 840 -270 0 0 {name=p126 lab=CoarseOneHot[15]}
C {lab_pin.sym} 840 -250 0 0 {name=p127 lab=CoarseOneHot[14]}
C {lab_pin.sym} 840 -230 0 0 {name=p128 lab=CoarseOneHot[13]}
C {lab_pin.sym} 840 -210 0 0 {name=p129 lab=CoarseOneHot[12]}
C {lab_pin.sym} 840 -190 0 0 {name=p130 lab=CoarseOneHot[11]}
C {lab_pin.sym} 840 -170 0 0 {name=p131 lab=CoarseOneHot[10]}
C {lab_pin.sym} 840 -150 0 0 {name=p132 lab=CoarseOneHot[9]}
C {lab_pin.sym} 840 -130 0 0 {name=p133 lab=CoarseOneHot[8]}
C {lab_wire.sym} 1720 -710 3 0 {name=p212 sig_type=std_logic lab=VddA18}
C {BiasBranch.sym} 1520 -520 0 0 {name=xBiasBranch2}
C {lab_wire.sym} 1740 -710 3 0 {name=p213 sig_type=std_logic lab=GndA}
C {lab_wire.sym} 1800 -710 3 0 {name=p214 sig_type=std_logic lab=BiasCB[7:0]}
C {lab_wire.sym} 1900 -710 3 0 {name=p215 sig_type=std_logic lab=BufferN}
C {lab_wire.sym} 1920 -710 3 0 {name=p216 sig_type=std_logic lab=BufferP}
C {lab_wire.sym} 2110 -580 0 0 {name=p217 sig_type=std_logic lab=Bias[2]}
C {lab_wire.sym} 1460 -90 0 1 {name=p218 sig_type=std_logic lab=LowBiasInterfaceEn[2]}
C {lab_wire.sym} 1460 -70 0 1 {name=p219 sig_type=std_logic lab=nLowBiasInterfaceEn[2]}
C {lab_wire.sym} 1460 -50 0 1 {name=p220 sig_type=std_logic lab=CoarseOneHotLowBiasEn[2]}
C {lab_wire.sym} 1460 -30 0 1 {name=p221 sig_type=std_logic lab=PowerDown[2]}
C {lab_wire.sym} 1460 -10 0 1 {name=p222 sig_type=std_logic lab=BIT0[2]}
C {lab_wire.sym} 1460 10 0 1 {name=p223 sig_type=std_logic lab=NBiasEn[2]}
C {lab_wire.sym} 1460 30 0 1 {name=p224 sig_type=std_logic lab=PBiasEn[2]}
C {lab_wire.sym} 1460 70 0 1 {name=p225 sig_type=std_logic lab=BiasDisabled[2]}
C {iopin.sym} 2100 -480 0 0 {name=p226 lab=PadBias[2]}
C {lab_pin.sym} 1680 -570 0 0 {name=p227 lab=FineCode[23]}
C {lab_pin.sym} 1680 -550 0 0 {name=p228 lab=FineCode[22]}
C {lab_pin.sym} 1680 -530 0 0 {name=p229 lab=FineCode[21]}
C {lab_pin.sym} 1680 -510 0 0 {name=p230 lab=FineCode[20]}
C {lab_pin.sym} 1680 -490 0 0 {name=p231 lab=FineCode[19]}
C {lab_pin.sym} 1680 -470 0 0 {name=p232 lab=FineCode[18]}
C {lab_pin.sym} 1680 -450 0 0 {name=p233 lab=FineCode[17]}
C {lab_pin.sym} 1680 -430 0 0 {name=p234 lab=FineCode[16]}
C {lab_pin.sym} 1680 -410 0 0 {name=p235 lab=nFineCode[23]}
C {lab_pin.sym} 1680 -390 0 0 {name=p236 lab=nFineCode[22]}
C {lab_pin.sym} 1680 -370 0 0 {name=p237 lab=nFineCode[21]}
C {lab_pin.sym} 1680 -350 0 0 {name=p238 lab=nFineCode[20]}
C {lab_pin.sym} 1680 -330 0 0 {name=p239 lab=nFineCode[19]}
C {lab_pin.sym} 1680 -310 0 0 {name=p240 lab=nFineCode[18]}
C {lab_pin.sym} 1680 -290 0 0 {name=p241 lab=nFineCode[17]}
C {lab_pin.sym} 1680 -270 0 0 {name=p242 lab=nFineCode[16]}
C {lab_pin.sym} 1680 -250 0 0 {name=p243 lab=CoarseOneHot[23]}
C {lab_pin.sym} 1680 -230 0 0 {name=p244 lab=CoarseOneHot[22]}
C {lab_pin.sym} 1680 -210 0 0 {name=p245 lab=CoarseOneHot[21]}
C {lab_pin.sym} 1680 -190 0 0 {name=p246 lab=CoarseOneHot[20]}
C {lab_pin.sym} 1680 -170 0 0 {name=p247 lab=CoarseOneHot[19]}
C {lab_pin.sym} 1680 -150 0 0 {name=p248 lab=CoarseOneHot[18]}
C {lab_pin.sym} 1680 -130 0 0 {name=p249 lab=CoarseOneHot[17]}
C {lab_pin.sym} 1680 -110 0 0 {name=p250 lab=CoarseOneHot[16]}
C {lab_wire.sym} 2500 -710 3 0 {name=p251 sig_type=std_logic lab=VddA18}
C {BiasBranch.sym} 2300 -520 0 0 {name=xBiasBranch3}
C {lab_wire.sym} 2520 -710 3 0 {name=p252 sig_type=std_logic lab=GndA}
C {lab_wire.sym} 2580 -710 3 0 {name=p253 sig_type=std_logic lab=BiasCB[7:0]}
C {lab_wire.sym} 2680 -710 3 0 {name=p254 sig_type=std_logic lab=BufferN}
C {lab_wire.sym} 2700 -710 3 0 {name=p255 sig_type=std_logic lab=BufferP}
C {lab_wire.sym} 2890 -580 0 0 {name=p256 sig_type=std_logic lab=Bias[3]}
C {lab_wire.sym} 2240 -90 0 1 {name=p257 sig_type=std_logic lab=LowBiasInterfaceEn[3]}
C {lab_wire.sym} 2240 -70 0 1 {name=p258 sig_type=std_logic lab=nLowBiasInterfaceEn[3]}
C {lab_wire.sym} 2240 -50 0 1 {name=p259 sig_type=std_logic lab=CoarseOneHotLowBiasEn[3]}
C {lab_wire.sym} 2240 -30 0 1 {name=p260 sig_type=std_logic lab=PowerDown[3]}
C {lab_wire.sym} 2240 -10 0 1 {name=p261 sig_type=std_logic lab=BIT0[3]}
C {lab_wire.sym} 2240 10 0 1 {name=p262 sig_type=std_logic lab=NBiasEn[3]}
C {lab_wire.sym} 2240 30 0 1 {name=p263 sig_type=std_logic lab=PBiasEn[3]}
C {lab_wire.sym} 2240 70 0 1 {name=p264 sig_type=std_logic lab=BiasDisabled[3]}
C {iopin.sym} 2880 -480 0 0 {name=p265 lab=PadBias[3]}
C {lab_pin.sym} 2460 -570 0 0 {name=p266 lab=FineCode[31]}
C {lab_pin.sym} 2460 -550 0 0 {name=p267 lab=FineCode[30]}
C {lab_pin.sym} 2460 -530 0 0 {name=p268 lab=FineCode[29]}
C {lab_pin.sym} 2460 -510 0 0 {name=p269 lab=FineCode[28]}
C {lab_pin.sym} 2460 -490 0 0 {name=p270 lab=FineCode[27]}
C {lab_pin.sym} 2460 -470 0 0 {name=p271 lab=FineCode[26]}
C {lab_pin.sym} 2460 -450 0 0 {name=p272 lab=FineCode[25]}
C {lab_pin.sym} 2460 -430 0 0 {name=p273 lab=FineCode[24]}
C {lab_pin.sym} 2460 -410 0 0 {name=p274 lab=nFineCode[31]}
C {lab_pin.sym} 2460 -390 0 0 {name=p275 lab=nFineCode[30]}
C {lab_pin.sym} 2460 -370 0 0 {name=p276 lab=nFineCode[29]}
C {lab_pin.sym} 2460 -350 0 0 {name=p277 lab=nFineCode[28]}
C {lab_pin.sym} 2460 -330 0 0 {name=p278 lab=nFineCode[27]}
C {lab_pin.sym} 2460 -310 0 0 {name=p279 lab=nFineCode[26]}
C {lab_pin.sym} 2460 -290 0 0 {name=p280 lab=nFineCode[25]}
C {lab_pin.sym} 2460 -270 0 0 {name=p281 lab=nFineCode[24]}
C {lab_pin.sym} 2460 -250 0 0 {name=p282 lab=CoarseOneHot[31]}
C {lab_pin.sym} 2460 -230 0 0 {name=p283 lab=CoarseOneHot[30]}
C {lab_pin.sym} 2460 -210 0 0 {name=p284 lab=CoarseOneHot[29]}
C {lab_pin.sym} 2460 -190 0 0 {name=p285 lab=CoarseOneHot[28]}
C {lab_pin.sym} 2460 -170 0 0 {name=p286 lab=CoarseOneHot[27]}
C {lab_pin.sym} 2460 -150 0 0 {name=p287 lab=CoarseOneHot[26]}
C {lab_pin.sym} 2460 -130 0 0 {name=p288 lab=CoarseOneHot[25]}
C {lab_pin.sym} 2460 -110 0 0 {name=p289 lab=CoarseOneHot[24]}
C {lab_wire.sym} 3340 -690 3 0 {name=p290 sig_type=std_logic lab=VddA18}
C {BiasBranch.sym} 3140 -500 0 0 {name=xBiasBranch4}
C {lab_wire.sym} 3360 -690 3 0 {name=p291 sig_type=std_logic lab=GndA}
C {lab_wire.sym} 3420 -690 3 0 {name=p292 sig_type=std_logic lab=BiasCB[7:0]}
C {lab_wire.sym} 3520 -690 3 0 {name=p293 sig_type=std_logic lab=BufferN}
C {lab_wire.sym} 3540 -690 3 0 {name=p294 sig_type=std_logic lab=BufferP}
C {lab_wire.sym} 3730 -560 0 0 {name=p295 sig_type=std_logic lab=Bias[4]}
C {lab_wire.sym} 3080 -70 0 1 {name=p296 sig_type=std_logic lab=LowBiasInterfaceEn[4]}
C {lab_wire.sym} 3080 -50 0 1 {name=p297 sig_type=std_logic lab=nLowBiasInterfaceEn[4]}
C {lab_wire.sym} 3080 -30 0 1 {name=p298 sig_type=std_logic lab=CoarseOneHotLowBiasEn[4]}
C {lab_wire.sym} 3080 -10 0 1 {name=p299 sig_type=std_logic lab=PowerDown[4]}
C {lab_wire.sym} 3080 10 0 1 {name=p300 sig_type=std_logic lab=BIT0[4]}
C {lab_wire.sym} 3080 30 0 1 {name=p301 sig_type=std_logic lab=NBiasEn[4]}
C {lab_wire.sym} 3080 50 0 1 {name=p302 sig_type=std_logic lab=PBiasEn[4]}
C {lab_wire.sym} 3080 90 0 1 {name=p303 sig_type=std_logic lab=BiasDisabled[4]}
C {iopin.sym} 3720 -460 0 0 {name=p304 lab=PadBias[4]}
C {lab_pin.sym} 3300 -550 0 0 {name=p305 lab=FineCode[39]}
C {lab_pin.sym} 3300 -530 0 0 {name=p306 lab=FineCode[38]}
C {lab_pin.sym} 3300 -510 0 0 {name=p307 lab=FineCode[37]}
C {lab_pin.sym} 3300 -490 0 0 {name=p308 lab=FineCode[36]}
C {lab_pin.sym} 3300 -470 0 0 {name=p309 lab=FineCode[35]}
C {lab_pin.sym} 3300 -450 0 0 {name=p310 lab=FineCode[34]}
C {lab_pin.sym} 3300 -430 0 0 {name=p311 lab=FineCode[33]}
C {lab_pin.sym} 3300 -410 0 0 {name=p312 lab=FineCode[32]}
C {lab_pin.sym} 3300 -390 0 0 {name=p313 lab=nFineCode[39]}
C {lab_pin.sym} 3300 -370 0 0 {name=p314 lab=nFineCode[38]}
C {lab_pin.sym} 3300 -350 0 0 {name=p315 lab=nFineCode[37]}
C {lab_pin.sym} 3300 -330 0 0 {name=p316 lab=nFineCode[36]}
C {lab_pin.sym} 3300 -310 0 0 {name=p317 lab=nFineCode[35]}
C {lab_pin.sym} 3300 -290 0 0 {name=p318 lab=nFineCode[34]}
C {lab_pin.sym} 3300 -270 0 0 {name=p319 lab=nFineCode[33]}
C {lab_pin.sym} 3300 -250 0 0 {name=p320 lab=nFineCode[32]}
C {lab_pin.sym} 3300 -230 0 0 {name=p321 lab=CoarseOneHot[39]}
C {lab_pin.sym} 3300 -210 0 0 {name=p322 lab=CoarseOneHot[38]}
C {lab_pin.sym} 3300 -190 0 0 {name=p323 lab=CoarseOneHot[37]}
C {lab_pin.sym} 3300 -170 0 0 {name=p324 lab=CoarseOneHot[36]}
C {lab_pin.sym} 3300 -150 0 0 {name=p325 lab=CoarseOneHot[35]}
C {lab_pin.sym} 3300 -130 0 0 {name=p326 lab=CoarseOneHot[34]}
C {lab_pin.sym} 3300 -110 0 0 {name=p327 lab=CoarseOneHot[33]}
C {lab_pin.sym} 3300 -90 0 0 {name=p328 lab=CoarseOneHot[32]}
C {lab_wire.sym} 4120 -690 3 0 {name=p329 sig_type=std_logic lab=VddA18}
C {BiasBranch.sym} 3920 -500 0 0 {name=xBiasBranch5}
C {lab_wire.sym} 4140 -690 3 0 {name=p330 sig_type=std_logic lab=GndA}
C {lab_wire.sym} 4200 -690 3 0 {name=p331 sig_type=std_logic lab=BiasCB[7:0]}
C {lab_wire.sym} 4300 -690 3 0 {name=p332 sig_type=std_logic lab=BufferN}
C {lab_wire.sym} 4320 -690 3 0 {name=p333 sig_type=std_logic lab=BufferP}
C {lab_wire.sym} 4510 -560 0 0 {name=p334 sig_type=std_logic lab=Bias[5]}
C {lab_wire.sym} 3860 -70 0 1 {name=p335 sig_type=std_logic lab=LowBiasInterfaceEn[5]}
C {lab_wire.sym} 3860 -50 0 1 {name=p336 sig_type=std_logic lab=nLowBiasInterfaceEn[5]}
C {lab_wire.sym} 3860 -30 0 1 {name=p337 sig_type=std_logic lab=CoarseOneHotLowBiasEn[5]}
C {lab_wire.sym} 3860 -10 0 1 {name=p338 sig_type=std_logic lab=PowerDown[5]}
C {lab_wire.sym} 3860 10 0 1 {name=p339 sig_type=std_logic lab=BIT0[5]}
C {lab_wire.sym} 3860 30 0 1 {name=p340 sig_type=std_logic lab=NBiasEn[5]}
C {lab_wire.sym} 3860 50 0 1 {name=p341 sig_type=std_logic lab=PBiasEn[5]}
C {lab_wire.sym} 3860 90 0 1 {name=p342 sig_type=std_logic lab=BiasDisabled[5]}
C {iopin.sym} 4500 -460 0 0 {name=p343 lab=PadBias[5]}
C {lab_pin.sym} 4080 -550 0 0 {name=p344 lab=FineCode[47]}
C {lab_pin.sym} 4080 -530 0 0 {name=p345 lab=FineCode[46]}
C {lab_pin.sym} 4080 -510 0 0 {name=p346 lab=FineCode[45]}
C {lab_pin.sym} 4080 -490 0 0 {name=p347 lab=FineCode[44]}
C {lab_pin.sym} 4080 -470 0 0 {name=p348 lab=FineCode[43]}
C {lab_pin.sym} 4080 -450 0 0 {name=p349 lab=FineCode[42]}
C {lab_pin.sym} 4080 -430 0 0 {name=p350 lab=FineCode[41]}
C {lab_pin.sym} 4080 -410 0 0 {name=p351 lab=FineCode[40]}
C {lab_pin.sym} 4080 -390 0 0 {name=p352 lab=nFineCode[47]}
C {lab_pin.sym} 4080 -370 0 0 {name=p353 lab=nFineCode[46]}
C {lab_pin.sym} 4080 -350 0 0 {name=p354 lab=nFineCode[45]}
C {lab_pin.sym} 4080 -330 0 0 {name=p355 lab=nFineCode[44]}
C {lab_pin.sym} 4080 -310 0 0 {name=p356 lab=nFineCode[43]}
C {lab_pin.sym} 4080 -290 0 0 {name=p357 lab=nFineCode[42]}
C {lab_pin.sym} 4080 -270 0 0 {name=p358 lab=nFineCode[41]}
C {lab_pin.sym} 4080 -250 0 0 {name=p359 lab=nFineCode[40]}
C {lab_pin.sym} 4080 -230 0 0 {name=p360 lab=CoarseOneHot[47]}
C {lab_pin.sym} 4080 -210 0 0 {name=p361 lab=CoarseOneHot[46]}
C {lab_pin.sym} 4080 -190 0 0 {name=p362 lab=CoarseOneHot[45]}
C {lab_pin.sym} 4080 -170 0 0 {name=p363 lab=CoarseOneHot[44]}
C {lab_pin.sym} 4080 -150 0 0 {name=p364 lab=CoarseOneHot[43]}
C {lab_pin.sym} 4080 -130 0 0 {name=p365 lab=CoarseOneHot[42]}
C {lab_pin.sym} 4080 -110 0 0 {name=p366 lab=CoarseOneHot[41]}
C {lab_pin.sym} 4080 -90 0 0 {name=p367 lab=CoarseOneHot[40]}
C {lab_wire.sym} 4960 -670 3 0 {name=p368 sig_type=std_logic lab=VddA18}
C {BiasBranch.sym} 4760 -480 0 0 {name=xBiasBranch6}
C {lab_wire.sym} 4980 -670 3 0 {name=p369 sig_type=std_logic lab=GndA}
C {lab_wire.sym} 5040 -670 3 0 {name=p370 sig_type=std_logic lab=BiasCB[7:0]}
C {lab_wire.sym} 5140 -670 3 0 {name=p371 sig_type=std_logic lab=BufferN}
C {lab_wire.sym} 5160 -670 3 0 {name=p372 sig_type=std_logic lab=BufferP}
C {lab_wire.sym} 5350 -540 0 0 {name=p373 sig_type=std_logic lab=Bias[6]}
C {lab_wire.sym} 4700 -50 0 1 {name=p374 sig_type=std_logic lab=LowBiasInterfaceEn[6]}
C {lab_wire.sym} 4700 -30 0 1 {name=p375 sig_type=std_logic lab=nLowBiasInterfaceEn[6]}
C {lab_wire.sym} 4700 -10 0 1 {name=p376 sig_type=std_logic lab=CoarseOneHotLowBiasEn[6]}
C {lab_wire.sym} 4700 10 0 1 {name=p377 sig_type=std_logic lab=PowerDown[6]}
C {lab_wire.sym} 4700 30 0 1 {name=p378 sig_type=std_logic lab=BIT0[6]}
C {lab_wire.sym} 4700 50 0 1 {name=p379 sig_type=std_logic lab=NBiasEn[6]}
C {lab_wire.sym} 4700 70 0 1 {name=p380 sig_type=std_logic lab=PBiasEn[6]}
C {lab_wire.sym} 4700 110 0 1 {name=p381 sig_type=std_logic lab=BiasDisabled[6]}
C {iopin.sym} 5340 -440 0 0 {name=p382 lab=PadBias[6]}
C {lab_pin.sym} 4920 -530 0 0 {name=p383 lab=FineCode[55]}
C {lab_pin.sym} 4920 -510 0 0 {name=p384 lab=FineCode[54]}
C {lab_pin.sym} 4920 -490 0 0 {name=p385 lab=FineCode[53]}
C {lab_pin.sym} 4920 -470 0 0 {name=p386 lab=FineCode[52]}
C {lab_pin.sym} 4920 -450 0 0 {name=p387 lab=FineCode[51]}
C {lab_pin.sym} 4920 -430 0 0 {name=p388 lab=FineCode[50]}
C {lab_pin.sym} 4920 -410 0 0 {name=p389 lab=FineCode[49]}
C {lab_pin.sym} 4920 -390 0 0 {name=p390 lab=FineCode[48]}
C {lab_pin.sym} 4920 -370 0 0 {name=p391 lab=nFineCode[55]}
C {lab_pin.sym} 4920 -350 0 0 {name=p392 lab=nFineCode[54]}
C {lab_pin.sym} 4920 -330 0 0 {name=p393 lab=nFineCode[53]}
C {lab_pin.sym} 4920 -310 0 0 {name=p394 lab=nFineCode[52]}
C {lab_pin.sym} 4920 -290 0 0 {name=p395 lab=nFineCode[51]}
C {lab_pin.sym} 4920 -270 0 0 {name=p396 lab=nFineCode[50]}
C {lab_pin.sym} 4920 -250 0 0 {name=p397 lab=nFineCode[49]}
C {lab_pin.sym} 4920 -230 0 0 {name=p398 lab=nFineCode[48]}
C {lab_pin.sym} 4920 -210 0 0 {name=p399 lab=CoarseOneHot[55]}
C {lab_pin.sym} 4920 -190 0 0 {name=p400 lab=CoarseOneHot[54]}
C {lab_pin.sym} 4920 -170 0 0 {name=p401 lab=CoarseOneHot[53]}
C {lab_pin.sym} 4920 -150 0 0 {name=p402 lab=CoarseOneHot[52]}
C {lab_pin.sym} 4920 -130 0 0 {name=p403 lab=CoarseOneHot[51]}
C {lab_pin.sym} 4920 -110 0 0 {name=p404 lab=CoarseOneHot[50]}
C {lab_pin.sym} 4920 -90 0 0 {name=p405 lab=CoarseOneHot[49]}
C {lab_pin.sym} 4920 -70 0 0 {name=p406 lab=CoarseOneHot[48]}
C {lab_wire.sym} 5740 -670 3 0 {name=p407 sig_type=std_logic lab=VddA18}
C {BiasBranch.sym} 5540 -480 0 0 {name=xBiasBranch7}
C {lab_wire.sym} 5760 -670 3 0 {name=p408 sig_type=std_logic lab=GndA}
C {lab_wire.sym} 5820 -670 3 0 {name=p409 sig_type=std_logic lab=BiasCB[7:0]}
C {lab_wire.sym} 5920 -670 3 0 {name=p410 sig_type=std_logic lab=BufferN}
C {lab_wire.sym} 5940 -670 3 0 {name=p411 sig_type=std_logic lab=BufferP}
C {lab_wire.sym} 6130 -540 0 0 {name=p412 sig_type=std_logic lab=Bias[7]}
C {lab_wire.sym} 5480 -50 0 1 {name=p413 sig_type=std_logic lab=LowBiasInterfaceEn[7]}
C {lab_wire.sym} 5480 -30 0 1 {name=p414 sig_type=std_logic lab=nLowBiasInterfaceEn[7]}
C {lab_wire.sym} 5480 -10 0 1 {name=p415 sig_type=std_logic lab=CoarseOneHotLowBiasEn[7]}
C {lab_wire.sym} 5480 10 0 1 {name=p416 sig_type=std_logic lab=PowerDown[7]}
C {lab_wire.sym} 5480 30 0 1 {name=p417 sig_type=std_logic lab=BIT0[7]}
C {lab_wire.sym} 5480 50 0 1 {name=p418 sig_type=std_logic lab=NBiasEn[7]}
C {lab_wire.sym} 5480 70 0 1 {name=p419 sig_type=std_logic lab=PBiasEn[7]}
C {lab_wire.sym} 5480 110 0 1 {name=p420 sig_type=std_logic lab=BiasDisabled[7]}
C {iopin.sym} 6120 -440 0 0 {name=p421 lab=PadBias[7]}
C {lab_pin.sym} 5700 -530 0 0 {name=p422 lab=FineCode[63]}
C {lab_pin.sym} 5700 -510 0 0 {name=p423 lab=FineCode[62]}
C {lab_pin.sym} 5700 -490 0 0 {name=p424 lab=FineCode[61]}
C {lab_pin.sym} 5700 -470 0 0 {name=p425 lab=FineCode[60]}
C {lab_pin.sym} 5700 -450 0 0 {name=p426 lab=FineCode[59]}
C {lab_pin.sym} 5700 -430 0 0 {name=p427 lab=FineCode[58]}
C {lab_pin.sym} 5700 -410 0 0 {name=p428 lab=FineCode[57]}
C {lab_pin.sym} 5700 -390 0 0 {name=p429 lab=FineCode[56]}
C {lab_pin.sym} 5700 -370 0 0 {name=p430 lab=nFineCode[63]}
C {lab_pin.sym} 5700 -350 0 0 {name=p431 lab=nFineCode[62]}
C {lab_pin.sym} 5700 -330 0 0 {name=p432 lab=nFineCode[61]}
C {lab_pin.sym} 5700 -310 0 0 {name=p433 lab=nFineCode[60]}
C {lab_pin.sym} 5700 -290 0 0 {name=p434 lab=nFineCode[59]}
C {lab_pin.sym} 5700 -270 0 0 {name=p435 lab=nFineCode[58]}
C {lab_pin.sym} 5700 -250 0 0 {name=p436 lab=nFineCode[57]}
C {lab_pin.sym} 5700 -230 0 0 {name=p437 lab=nFineCode[56]}
C {lab_pin.sym} 5700 -210 0 0 {name=p438 lab=CoarseOneHot[63]}
C {lab_pin.sym} 5700 -190 0 0 {name=p439 lab=CoarseOneHot[62]}
C {lab_pin.sym} 5700 -170 0 0 {name=p440 lab=CoarseOneHot[61]}
C {lab_pin.sym} 5700 -150 0 0 {name=p441 lab=CoarseOneHot[60]}
C {lab_pin.sym} 5700 -130 0 0 {name=p442 lab=CoarseOneHot[59]}
C {lab_pin.sym} 5700 -110 0 0 {name=p443 lab=CoarseOneHot[58]}
C {lab_pin.sym} 5700 -90 0 0 {name=p444 lab=CoarseOneHot[57]}
C {lab_pin.sym} 5700 -70 0 0 {name=p445 lab=CoarseOneHot[56]}
C {lab_wire.sym} 6580 -650 3 0 {name=p446 sig_type=std_logic lab=VddA18}
C {BiasBranch.sym} 6380 -460 0 0 {name=xBiasBranch8}
C {lab_wire.sym} 6600 -650 3 0 {name=p447 sig_type=std_logic lab=GndA}
C {lab_wire.sym} 6660 -650 3 0 {name=p448 sig_type=std_logic lab=BiasCB[7:0]}
C {lab_wire.sym} 6760 -650 3 0 {name=p449 sig_type=std_logic lab=BufferN}
C {lab_wire.sym} 6780 -650 3 0 {name=p450 sig_type=std_logic lab=BufferP}
C {lab_wire.sym} 6970 -520 0 0 {name=p451 sig_type=std_logic lab=Bias[8]}
C {lab_wire.sym} 6320 -30 0 1 {name=p452 sig_type=std_logic lab=LowBiasInterfaceEn[8]}
C {lab_wire.sym} 6320 -10 0 1 {name=p453 sig_type=std_logic lab=nLowBiasInterfaceEn[8]}
C {lab_wire.sym} 6320 10 0 1 {name=p454 sig_type=std_logic lab=CoarseOneHotLowBiasEn[8]}
C {lab_wire.sym} 6320 30 0 1 {name=p455 sig_type=std_logic lab=PowerDown[8]}
C {lab_wire.sym} 6320 50 0 1 {name=p456 sig_type=std_logic lab=BIT0[8]}
C {lab_wire.sym} 6320 70 0 1 {name=p457 sig_type=std_logic lab=NBiasEn[8]}
C {lab_wire.sym} 6320 90 0 1 {name=p458 sig_type=std_logic lab=PBiasEn[8]}
C {lab_wire.sym} 6320 130 0 1 {name=p459 sig_type=std_logic lab=BiasDisabled[8]}
C {iopin.sym} 6960 -420 0 0 {name=p460 lab=PadBias[8]}
C {lab_pin.sym} 6540 -510 0 0 {name=p461 lab=FineCode[71]}
C {lab_pin.sym} 6540 -490 0 0 {name=p462 lab=FineCode[70]}
C {lab_pin.sym} 6540 -470 0 0 {name=p463 lab=FineCode[69]}
C {lab_pin.sym} 6540 -450 0 0 {name=p464 lab=FineCode[68]}
C {lab_pin.sym} 6540 -430 0 0 {name=p465 lab=FineCode[67]}
C {lab_pin.sym} 6540 -410 0 0 {name=p466 lab=FineCode[66]}
C {lab_pin.sym} 6540 -390 0 0 {name=p467 lab=FineCode[65]}
C {lab_pin.sym} 6540 -370 0 0 {name=p468 lab=FineCode[64]}
C {lab_pin.sym} 6540 -350 0 0 {name=p469 lab=nFineCode[71]}
C {lab_pin.sym} 6540 -330 0 0 {name=p470 lab=nFineCode[70]}
C {lab_pin.sym} 6540 -310 0 0 {name=p471 lab=nFineCode[69]}
C {lab_pin.sym} 6540 -290 0 0 {name=p472 lab=nFineCode[68]}
C {lab_pin.sym} 6540 -270 0 0 {name=p473 lab=nFineCode[67]}
C {lab_pin.sym} 6540 -250 0 0 {name=p474 lab=nFineCode[66]}
C {lab_pin.sym} 6540 -230 0 0 {name=p475 lab=nFineCode[65]}
C {lab_pin.sym} 6540 -210 0 0 {name=p476 lab=nFineCode[64]}
C {lab_pin.sym} 6540 -190 0 0 {name=p477 lab=CoarseOneHot[71]}
C {lab_pin.sym} 6540 -170 0 0 {name=p478 lab=CoarseOneHot[70]}
C {lab_pin.sym} 6540 -150 0 0 {name=p479 lab=CoarseOneHot[69]}
C {lab_pin.sym} 6540 -130 0 0 {name=p480 lab=CoarseOneHot[68]}
C {lab_pin.sym} 6540 -110 0 0 {name=p481 lab=CoarseOneHot[67]}
C {lab_pin.sym} 6540 -90 0 0 {name=p482 lab=CoarseOneHot[66]}
C {lab_pin.sym} 6540 -70 0 0 {name=p483 lab=CoarseOneHot[65]}
C {lab_pin.sym} 6540 -50 0 0 {name=p484 lab=CoarseOneHot[64]}
C {lab_wire.sym} 7360 -650 3 0 {name=p485 sig_type=std_logic lab=VddA18}
C {BiasBranch.sym} 7160 -460 0 0 {name=xBiasBranch9}
C {lab_wire.sym} 7380 -650 3 0 {name=p486 sig_type=std_logic lab=GndA}
C {lab_wire.sym} 7440 -650 3 0 {name=p487 sig_type=std_logic lab=BiasCB[7:0]}
C {lab_wire.sym} 7540 -650 3 0 {name=p488 sig_type=std_logic lab=BufferN}
C {lab_wire.sym} 7560 -650 3 0 {name=p489 sig_type=std_logic lab=BufferP}
C {lab_wire.sym} 7750 -520 0 0 {name=p490 sig_type=std_logic lab=Bias[9]}
C {lab_wire.sym} 7100 -30 0 1 {name=p491 sig_type=std_logic lab=LowBiasInterfaceEn[9]}
C {lab_wire.sym} 7100 -10 0 1 {name=p492 sig_type=std_logic lab=nLowBiasInterfaceEn[9]}
C {lab_wire.sym} 7100 10 0 1 {name=p493 sig_type=std_logic lab=CoarseOneHotLowBiasEn[9]}
C {lab_wire.sym} 7100 30 0 1 {name=p494 sig_type=std_logic lab=PowerDown[9]}
C {lab_wire.sym} 7100 50 0 1 {name=p495 sig_type=std_logic lab=BIT0[9]}
C {lab_wire.sym} 7100 70 0 1 {name=p496 sig_type=std_logic lab=NBiasEn[9]}
C {lab_wire.sym} 7100 90 0 1 {name=p497 sig_type=std_logic lab=PBiasEn[9]}
C {lab_wire.sym} 7100 130 0 1 {name=p498 sig_type=std_logic lab=BiasDisabled[9]}
C {iopin.sym} 7740 -420 0 0 {name=p499 lab=PadBias[9]}
C {lab_pin.sym} 7320 -510 0 0 {name=p500 lab=FineCode[79]}
C {lab_pin.sym} 7320 -490 0 0 {name=p501 lab=FineCode[78]}
C {lab_pin.sym} 7320 -470 0 0 {name=p502 lab=FineCode[77]}
C {lab_pin.sym} 7320 -450 0 0 {name=p503 lab=FineCode[76]}
C {lab_pin.sym} 7320 -430 0 0 {name=p504 lab=FineCode[75]}
C {lab_pin.sym} 7320 -410 0 0 {name=p505 lab=FineCode[74]}
C {lab_pin.sym} 7320 -390 0 0 {name=p506 lab=FineCode[73]}
C {lab_pin.sym} 7320 -370 0 0 {name=p507 lab=FineCode[72]}
C {lab_pin.sym} 7320 -350 0 0 {name=p508 lab=nFineCode[79]}
C {lab_pin.sym} 7320 -330 0 0 {name=p509 lab=nFineCode[78]}
C {lab_pin.sym} 7320 -310 0 0 {name=p510 lab=nFineCode[77]}
C {lab_pin.sym} 7320 -290 0 0 {name=p511 lab=nFineCode[76]}
C {lab_pin.sym} 7320 -270 0 0 {name=p512 lab=nFineCode[75]}
C {lab_pin.sym} 7320 -250 0 0 {name=p513 lab=nFineCode[74]}
C {lab_pin.sym} 7320 -230 0 0 {name=p514 lab=nFineCode[73]}
C {lab_pin.sym} 7320 -210 0 0 {name=p515 lab=nFineCode[72]}
C {lab_pin.sym} 7320 -190 0 0 {name=p516 lab=CoarseOneHot[79]}
C {lab_pin.sym} 7320 -170 0 0 {name=p517 lab=CoarseOneHot[78]}
C {lab_pin.sym} 7320 -150 0 0 {name=p518 lab=CoarseOneHot[77]}
C {lab_pin.sym} 7320 -130 0 0 {name=p519 lab=CoarseOneHot[76]}
C {lab_pin.sym} 7320 -110 0 0 {name=p520 lab=CoarseOneHot[75]}
C {lab_pin.sym} 7320 -90 0 0 {name=p521 lab=CoarseOneHot[74]}
C {lab_pin.sym} 7320 -70 0 0 {name=p522 lab=CoarseOneHot[73]}
C {lab_pin.sym} 7320 -50 0 0 {name=p523 lab=CoarseOneHot[72]}
C {lab_wire.sym} 8200 -630 3 0 {name=p524 sig_type=std_logic lab=VddA18}
C {BiasBranch.sym} 8000 -440 0 0 {name=xBiasBranch10}
C {lab_wire.sym} 8220 -630 3 0 {name=p525 sig_type=std_logic lab=GndA}
C {lab_wire.sym} 8280 -630 3 0 {name=p526 sig_type=std_logic lab=BiasCB[7:0]}
C {lab_wire.sym} 8380 -630 3 0 {name=p527 sig_type=std_logic lab=BufferN}
C {lab_wire.sym} 8400 -630 3 0 {name=p528 sig_type=std_logic lab=BufferP}
C {lab_wire.sym} 8590 -500 0 0 {name=p529 sig_type=std_logic lab=Bias[10]}
C {lab_wire.sym} 7940 -10 0 1 {name=p530 sig_type=std_logic lab=LowBiasInterfaceEn[10]}
C {lab_wire.sym} 7940 10 0 1 {name=p531 sig_type=std_logic lab=nLowBiasInterfaceEn[10]}
C {lab_wire.sym} 7940 30 0 1 {name=p532 sig_type=std_logic lab=CoarseOneHotLowBiasEn[10]}
C {lab_wire.sym} 7940 50 0 1 {name=p533 sig_type=std_logic lab=PowerDown[10]}
C {lab_wire.sym} 7940 70 0 1 {name=p534 sig_type=std_logic lab=BIT0[10]}
C {lab_wire.sym} 7940 90 0 1 {name=p535 sig_type=std_logic lab=NBiasEn[10]}
C {lab_wire.sym} 7940 110 0 1 {name=p536 sig_type=std_logic lab=PBiasEn[10]}
C {lab_wire.sym} 7940 150 0 1 {name=p537 sig_type=std_logic lab=BiasDisabled[10]}
C {iopin.sym} 8580 -400 0 0 {name=p538 lab=PadBias[10]}
C {lab_pin.sym} 8160 -490 0 0 {name=p539 lab=FineCode[87]}
C {lab_pin.sym} 8160 -470 0 0 {name=p540 lab=FineCode[86]}
C {lab_pin.sym} 8160 -450 0 0 {name=p541 lab=FineCode[85]}
C {lab_pin.sym} 8160 -430 0 0 {name=p542 lab=FineCode[84]}
C {lab_pin.sym} 8160 -410 0 0 {name=p543 lab=FineCode[83]}
C {lab_pin.sym} 8160 -390 0 0 {name=p544 lab=FineCode[82]}
C {lab_pin.sym} 8160 -370 0 0 {name=p545 lab=FineCode[81]}
C {lab_pin.sym} 8160 -350 0 0 {name=p546 lab=FineCode[80]}
C {lab_pin.sym} 8160 -330 0 0 {name=p547 lab=nFineCode[87]}
C {lab_pin.sym} 8160 -310 0 0 {name=p548 lab=nFineCode[86]}
C {lab_pin.sym} 8160 -290 0 0 {name=p549 lab=nFineCode[85]}
C {lab_pin.sym} 8160 -270 0 0 {name=p550 lab=nFineCode[84]}
C {lab_pin.sym} 8160 -250 0 0 {name=p551 lab=nFineCode[83]}
C {lab_pin.sym} 8160 -230 0 0 {name=p552 lab=nFineCode[82]}
C {lab_pin.sym} 8160 -210 0 0 {name=p553 lab=nFineCode[81]}
C {lab_pin.sym} 8160 -190 0 0 {name=p554 lab=nFineCode[80]}
C {lab_pin.sym} 8160 -170 0 0 {name=p555 lab=CoarseOneHot[87]}
C {lab_pin.sym} 8160 -150 0 0 {name=p556 lab=CoarseOneHot[86]}
C {lab_pin.sym} 8160 -130 0 0 {name=p557 lab=CoarseOneHot[85]}
C {lab_pin.sym} 8160 -110 0 0 {name=p558 lab=CoarseOneHot[84]}
C {lab_pin.sym} 8160 -90 0 0 {name=p559 lab=CoarseOneHot[83]}
C {lab_pin.sym} 8160 -70 0 0 {name=p560 lab=CoarseOneHot[82]}
C {lab_pin.sym} 8160 -50 0 0 {name=p561 lab=CoarseOneHot[81]}
C {lab_pin.sym} 8160 -30 0 0 {name=p562 lab=CoarseOneHot[80]}
