** sch_path: analog/xschem/tb_PixelPhotoreceptor_dc.sch
**.subckt tb_PixelPhotoreceptor_dc
IPrBp PrBp gnd {xPrBp}
XMPrBp PrBp PrBp vdd vdd sky130_fd_pr__pfet_01v8_hvt L=0.15 W=1 nf=1 ad='int((1 + 1)/2) * 1 / 1 * 0.29'
+ as='int((1 + 2)/2) * 1 / 1 * 0.29' pd='2*int((1 + 1)/2) * (1 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (1 / 1 + 0.29)'
+ nrd='0.29 / 1 ' nrs='0.29 / 1 ' sa=0 sb=0 sd=0 mult=1 m=1
IPrSFBp PrSFBp gnd {xPrSFBp}
XMPrSFBp PrSFBp PrSFBp vdd vdd sky130_fd_pr__pfet_01v8 L=8 W=1 nf=2 ad='int((2 + 1)/2) * 1 / 2 * 0.29'
+ as='int((2 + 2)/2) * 1 / 2 * 0.29' pd='2*int((2 + 1)/2) * (1 / 2 + 0.29)' ps='2*int((2 + 2)/2) * (1 / 2 + 0.29)'
+ nrd='0.29 / 1 ' nrs='0.29 / 1 ' sa=0 sb=0 sd=0 mult=1 m=1
xpr vdd PrBp gnd vpd_in vpr PixelPhotoreceptor
xsf vdd PrSFBp gnd vpr vsf PixelSourceFollower
Bipd1 vpd gnd I = pow(10, v(exp))
CloadPD1 vpd gnd 'xCloadPD' m=1
Vmeas_ipd1 vpd_in vpd 0
* noconn vsf
Vexp exp gnd 0
Vgnd gnd GND! 0
Vvdd vdd GND! {xvdd}
**** begin user architecture code

** opencircuitdesign pdks install
.lib $::SKYWATER_MODELS/sky130.lib.spice tt
.include [xschem get current_dirname]/dvs_readout_ctrl.spice




** Convergence options for nA-range weak-inversion pixel circuit
** gmin=1e-15: at 1V node this is 1fA shunt, negligible vs nA signals
** method=gear: damps numerical ringing on stiff circuits (fast digital + slow analog)
** trtol=1: conservative timestep control prevents overshoot at edges
.option gmin=1e-16 abstol=1e-15 vntol=1e-9 reltol=1e-4 chgtol=1e-16
.option method=gear maxord=2 trtol=1
.option itl1=500 itl2=200 itl4=50
.option gminsteps=200 srcsteps=200
.option ramptime=100n

.dc Vexp -14 -7 0.2


.param xvdd = 1.8
*.param xipd = 1e-9
.param xPrBp = 10n
.param xPrSFBp = 100p
.param xCloadPD = 30f

** xipd swept via Vexp: Iipd uses behavioral expression

*Small Iphoto testing

.save all



**** end user architecture code
**.ends

* expanding   symbol:  PixelPhotoreceptor.sym # of pins=5
** sym_path: analog/xschem/PixelPhotoreceptor.sym
** sch_path: analog/xschem/PixelPhotoreceptor.sch
.subckt PixelPhotoreceptor vdd PrBp gnd vpd vpr
*.iopin PrBp
*.iopin vdd
*.iopin vpd
*.iopin gnd
*.iopin vpr
XMpd vdd vpr vpd gnd sky130_fd_pr__nfet_01v8 L=0.3 W=0.42 nf=1 ad='int((1 + 1)/2) * 0.42 / 1 * 0.29'
+ as='int((1 + 2)/2) * 0.42 / 1 * 0.29' pd='2*int((1 + 1)/2) * (0.42 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (0.42 / 1 + 0.29)'
+ nrd='0.29 / 0.42 ' nrs='0.29 / 0.42 ' sa=0 sb=0 sd=0 mult=1 m=1
XMpr_amp vpr vpd gnd gnd sky130_fd_pr__nfet_01v8 L=0.3 W=0.42 nf=1 ad='int((1 + 1)/2) * 0.42 / 1 * 0.29'
+ as='int((1 + 2)/2) * 0.42 / 1 * 0.29' pd='2*int((1 + 1)/2) * (0.42 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (0.42 / 1 + 0.29)'
+ nrd='0.29 / 0.42 ' nrs='0.29 / 0.42 ' sa=0 sb=0 sd=0 mult=1 m=1
XMprBias vpr PrBp vdd vdd sky130_fd_pr__pfet_01v8_hvt L=0.15 W=0.5 nf=1 ad='int((1 + 1)/2) * 0.5 / 1 * 0.29'
+ as='int((1 + 2)/2) * 0.5 / 1 * 0.29' pd='2*int((1 + 1)/2) * (0.5 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (0.5 / 1 + 0.29)'
+ nrd='0.29 / 0.5 ' nrs='0.29 / 0.5 ' sa=0 sb=0 sd=0 mult=1 m=1
.ends


* expanding   symbol:  PixelSourceFollower.sym # of pins=5
** sym_path: analog/xschem/PixelSourceFollower.sym
** sch_path: analog/xschem/PixelSourceFollower.sch
.subckt PixelSourceFollower vdd PrSFBp gnd vpr vsf
*.iopin gnd
*.iopin PrSFBp
*.iopin vpr
*.iopin vsf
*.iopin vdd
XMsfBias vsf PrSFBp vdd vdd sky130_fd_pr__pfet_01v8 L=1.6 W=0.42 nf=1 ad='int((1 + 1)/2) * 0.42 / 1 * 0.29'
+ as='int((1 + 2)/2) * 0.42 / 1 * 0.29' pd='2*int((1 + 1)/2) * (0.42 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (0.42 / 1 + 0.29)'
+ nrd='0.29 / 0.42 ' nrs='0.29 / 0.42 ' sa=0 sb=0 sd=0 mult=1 m=1
XMsf gnd vpr vsf vdd sky130_fd_pr__pfet_01v8 L=0.25 W=0.42 nf=1 ad='int((1 + 1)/2) * 0.42 / 1 * 0.29'
+ as='int((1 + 2)/2) * 0.42 / 1 * 0.29' pd='2*int((1 + 1)/2) * (0.42 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (0.42 / 1 + 0.29)'
+ nrd='0.29 / 0.42 ' nrs='0.29 / 0.42 ' sa=0 sb=0 sd=0 mult=1 m=1
.ends

.GLOBAL GND!
.end
