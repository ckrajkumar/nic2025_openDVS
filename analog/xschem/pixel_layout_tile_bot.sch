v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
N 240 -540 320 -540 {lab=VTHRESH}
N 240 -520 320 -520 {lab=nDETECT}
N 240 -500 320 -500 {lab=DETECT}
N 11140 -380 11140 -300 {lab=pixRst[0]}
N 10900 -380 10900 -300 {lab=pixRst[1]}
N 11080 -380 11080 -300 {lab=voutn[0]}
N 10960 -380 10960 -300 {lab=voutn[1]}
N 10800 -380 10800 -300 {lab=pixRst[2]}
N 10560 -380 10560 -300 {lab=pixRst[3]}
N 10740 -380 10740 -300 {lab=voutn[2]}
N 10620 -380 10620 -300 {lab=voutn[3]}
N 10460 -380 10460 -300 {lab=pixRst[4]}
N 10220 -380 10220 -300 {lab=pixRst[5]}
N 10400 -380 10400 -300 {lab=voutn[4]}
N 10280 -380 10280 -300 {lab=voutn[5]}
N 10120 -380 10120 -300 {lab=pixRst[6]}
N 9880 -380 9880 -300 {lab=pixRst[7]}
N 10060 -380 10060 -300 {lab=voutn[6]}
N 9940 -380 9940 -300 {lab=voutn[7]}
N 9780 -380 9780 -300 {lab=pixRst[8]}
N 9540 -380 9540 -300 {lab=pixRst[9]}
N 9720 -380 9720 -300 {lab=voutn[8]}
N 9600 -380 9600 -300 {lab=voutn[9]}
N 9440 -380 9440 -300 {lab=pixRst[10]}
N 9200 -380 9200 -300 {lab=pixRst[11]}
N 9380 -380 9380 -300 {lab=voutn[10]}
N 9260 -380 9260 -300 {lab=voutn[11]}
N 9100 -380 9100 -300 {lab=pixRst[12]}
N 8860 -380 8860 -300 {lab=pixRst[13]}
N 9040 -380 9040 -300 {lab=voutn[12]}
N 8920 -380 8920 -300 {lab=voutn[13]}
N 8760 -380 8760 -300 {lab=pixRst[14]}
N 8520 -380 8520 -300 {lab=pixRst[15]}
N 8700 -380 8700 -300 {lab=voutn[14]}
N 8580 -380 8580 -300 {lab=voutn[15]}
N 8420 -380 8420 -300 {lab=pixRst[16]}
N 8180 -380 8180 -300 {lab=pixRst[17]}
N 8360 -380 8360 -300 {lab=voutn[16]}
N 8240 -380 8240 -300 {lab=voutn[17]}
N 8080 -380 8080 -300 {lab=pixRst[18]}
N 7840 -380 7840 -300 {lab=pixRst[19]}
N 8020 -380 8020 -300 {lab=voutn[18]}
N 7900 -380 7900 -300 {lab=voutn[19]}
N 7740 -380 7740 -300 {lab=pixRst[20]}
N 7500 -380 7500 -300 {lab=pixRst[21]}
N 7680 -380 7680 -300 {lab=voutn[20]}
N 7560 -380 7560 -300 {lab=voutn[21]}
N 7400 -380 7400 -300 {lab=pixRst[22]}
N 7160 -380 7160 -300 {lab=pixRst[23]}
N 7340 -380 7340 -300 {lab=voutn[22]}
N 7220 -380 7220 -300 {lab=voutn[23]}
N 7060 -380 7060 -300 {lab=pixRst[24]}
N 6820 -380 6820 -300 {lab=pixRst[25]}
N 7000 -380 7000 -300 {lab=voutn[24]}
N 6880 -380 6880 -300 {lab=voutn[25]}
N 6720 -380 6720 -300 {lab=pixRst[26]}
N 6480 -380 6480 -300 {lab=pixRst[27]}
N 6660 -380 6660 -300 {lab=voutn[26]}
N 6540 -380 6540 -300 {lab=voutn[27]}
N 6380 -380 6380 -300 {lab=pixRst[28]}
N 6140 -380 6140 -300 {lab=pixRst[29]}
N 6320 -380 6320 -300 {lab=voutn[28]}
N 6200 -380 6200 -300 {lab=voutn[29]}
N 6040 -380 6040 -300 {lab=pixRst[30]}
N 5800 -380 5800 -300 {lab=pixRst[31]}
N 5980 -380 5980 -300 {lab=voutn[30]}
N 5860 -380 5860 -300 {lab=voutn[31]}
N 5700 -380 5700 -300 {lab=pixRst[32]}
N 5460 -380 5460 -300 {lab=pixRst[33]}
N 5640 -380 5640 -300 {lab=voutn[32]}
N 5520 -380 5520 -300 {lab=voutn[33]}
N 5360 -380 5360 -300 {lab=pixRst[34]}
N 5120 -380 5120 -300 {lab=pixRst[35]}
N 5300 -380 5300 -300 {lab=voutn[34]}
N 5180 -380 5180 -300 {lab=voutn[35]}
N 5020 -380 5020 -300 {lab=pixRst[36]}
N 4780 -380 4780 -300 {lab=pixRst[37]}
N 4960 -380 4960 -300 {lab=voutn[36]}
N 4840 -380 4840 -300 {lab=voutn[37]}
N 4680 -380 4680 -300 {lab=pixRst[38]}
N 4440 -380 4440 -300 {lab=pixRst[39]}
N 4620 -380 4620 -300 {lab=voutn[38]}
N 4500 -380 4500 -300 {lab=voutn[39]}
N 4340 -380 4340 -300 {lab=pixRst[40]}
N 4100 -380 4100 -300 {lab=pixRst[41]}
N 4280 -380 4280 -300 {lab=voutn[40]}
N 4160 -380 4160 -300 {lab=voutn[41]}
N 4000 -380 4000 -300 {lab=pixRst[42]}
N 3760 -380 3760 -300 {lab=pixRst[43]}
N 3940 -380 3940 -300 {lab=voutn[42]}
N 3820 -380 3820 -300 {lab=voutn[43]}
N 3660 -380 3660 -300 {lab=pixRst[44]}
N 3420 -380 3420 -300 {lab=pixRst[45]}
N 3600 -380 3600 -300 {lab=voutn[44]}
N 3480 -380 3480 -300 {lab=voutn[45]}
N 3320 -380 3320 -300 {lab=pixRst[46]}
N 3080 -380 3080 -300 {lab=pixRst[47]}
N 3260 -380 3260 -300 {lab=voutn[46]}
N 3140 -380 3140 -300 {lab=voutn[47]}
N 2980 -380 2980 -300 {lab=pixRst[48]}
N 2740 -380 2740 -300 {lab=pixRst[49]}
N 2920 -380 2920 -300 {lab=voutn[48]}
N 2800 -380 2800 -300 {lab=voutn[49]}
N 2640 -380 2640 -300 {lab=pixRst[50]}
N 2400 -380 2400 -300 {lab=pixRst[51]}
N 2580 -380 2580 -300 {lab=voutn[50]}
N 2460 -380 2460 -300 {lab=voutn[51]}
N 2300 -380 2300 -300 {lab=pixRst[52]}
N 2060 -380 2060 -300 {lab=pixRst[53]}
N 2240 -380 2240 -300 {lab=voutn[52]}
N 2120 -380 2120 -300 {lab=voutn[53]}
N 1960 -380 1960 -300 {lab=pixRst[54]}
N 1720 -380 1720 -300 {lab=pixRst[55]}
N 1900 -380 1900 -300 {lab=voutn[54]}
N 1780 -380 1780 -300 {lab=voutn[55]}
N 1620 -380 1620 -300 {lab=pixRst[56]}
N 1380 -380 1380 -300 {lab=pixRst[57]}
N 1560 -380 1560 -300 {lab=voutn[56]}
N 1440 -380 1440 -300 {lab=voutn[57]}
N 1280 -380 1280 -300 {lab=pixRst[58]}
N 1040 -380 1040 -300 {lab=pixRst[59]}
N 1220 -380 1220 -300 {lab=voutn[58]}
N 1100 -380 1100 -300 {lab=voutn[59]}
N 940 -380 940 -300 {lab=pixRst[60]}
N 700 -380 700 -300 {lab=pixRst[61]}
N 880 -380 880 -300 {lab=voutn[60]}
N 760 -380 760 -300 {lab=voutn[61]}
N 600 -380 600 -300 {lab=pixRst[62]}
N 360 -380 360 -300 {lab=pixRst[63]}
N 540 -380 540 -300 {lab=voutn[62]}
N 420 -380 420 -300 {lab=voutn[63]}
N 240 -17010 320 -17010 {lab=rowReadOFF[0]}
N 240 -16990 320 -16990 {lab=rowReadON[0]}
N 240 -16970 320 -16970 {lab=rowReadOFF[1]}
N 240 -16950 320 -16950 {lab=rowReadON[1]}
N 240 -16490 320 -16490 {lab=rowReadOFF[2]}
N 240 -16470 320 -16470 {lab=rowReadON[2]}
N 240 -16450 320 -16450 {lab=rowReadOFF[3]}
N 240 -16430 320 -16430 {lab=rowReadON[3]}
N 240 -15970 320 -15970 {lab=rowReadOFF[4]}
N 240 -15950 320 -15950 {lab=rowReadON[4]}
N 240 -15930 320 -15930 {lab=rowReadOFF[5]}
N 240 -15910 320 -15910 {lab=rowReadON[5]}
N 240 -15450 320 -15450 {lab=rowReadOFF[6]}
N 240 -15430 320 -15430 {lab=rowReadON[6]}
N 240 -15410 320 -15410 {lab=rowReadOFF[7]}
N 240 -15390 320 -15390 {lab=rowReadON[7]}
N 240 -14930 320 -14930 {lab=rowReadOFF[8]}
N 240 -14910 320 -14910 {lab=rowReadON[8]}
N 240 -14890 320 -14890 {lab=rowReadOFF[9]}
N 240 -14870 320 -14870 {lab=rowReadON[9]}
N 240 -14410 320 -14410 {lab=rowReadOFF[10]}
N 240 -14390 320 -14390 {lab=rowReadON[10]}
N 240 -14370 320 -14370 {lab=rowReadOFF[11]}
N 240 -14350 320 -14350 {lab=rowReadON[11]}
N 240 -13890 320 -13890 {lab=rowReadOFF[12]}
N 240 -13870 320 -13870 {lab=rowReadON[12]}
N 240 -13850 320 -13850 {lab=rowReadOFF[13]}
N 240 -13830 320 -13830 {lab=rowReadON[13]}
N 240 -13370 320 -13370 {lab=rowReadOFF[14]}
N 240 -13350 320 -13350 {lab=rowReadON[14]}
N 240 -13330 320 -13330 {lab=rowReadOFF[15]}
N 240 -13310 320 -13310 {lab=rowReadON[15]}
N 240 -12850 320 -12850 {lab=rowReadOFF[16]}
N 240 -12830 320 -12830 {lab=rowReadON[16]}
N 240 -12810 320 -12810 {lab=rowReadOFF[17]}
N 240 -12790 320 -12790 {lab=rowReadON[17]}
N 240 -12330 320 -12330 {lab=rowReadOFF[18]}
N 240 -12310 320 -12310 {lab=rowReadON[18]}
N 240 -12290 320 -12290 {lab=rowReadOFF[19]}
N 240 -12270 320 -12270 {lab=rowReadON[19]}
N 240 -11810 320 -11810 {lab=rowReadOFF[20]}
N 240 -11790 320 -11790 {lab=rowReadON[20]}
N 240 -11770 320 -11770 {lab=rowReadOFF[21]}
N 240 -11750 320 -11750 {lab=rowReadON[21]}
N 240 -11290 320 -11290 {lab=rowReadOFF[22]}
N 240 -11270 320 -11270 {lab=rowReadON[22]}
N 240 -11250 320 -11250 {lab=rowReadOFF[23]}
N 240 -11230 320 -11230 {lab=rowReadON[23]}
N 240 -10770 320 -10770 {lab=rowReadOFF[24]}
N 240 -10750 320 -10750 {lab=rowReadON[24]}
N 240 -10730 320 -10730 {lab=rowReadOFF[25]}
N 240 -10710 320 -10710 {lab=rowReadON[25]}
N 240 -10250 320 -10250 {lab=rowReadOFF[26]}
N 240 -10230 320 -10230 {lab=rowReadON[26]}
N 240 -10210 320 -10210 {lab=rowReadOFF[27]}
N 240 -10190 320 -10190 {lab=rowReadON[27]}
N 240 -9730 320 -9730 {lab=rowReadOFF[28]}
N 240 -9710 320 -9710 {lab=rowReadON[28]}
N 240 -9690 320 -9690 {lab=rowReadOFF[29]}
N 240 -9670 320 -9670 {lab=rowReadON[29]}
N 240 -9210 320 -9210 {lab=rowReadOFF[30]}
N 240 -9190 320 -9190 {lab=rowReadON[30]}
N 240 -9170 320 -9170 {lab=rowReadOFF[31]}
N 240 -9150 320 -9150 {lab=rowReadON[31]}
N 240 -8690 320 -8690 {lab=rowReadOFF[32]}
N 240 -8670 320 -8670 {lab=rowReadON[32]}
N 240 -8650 320 -8650 {lab=rowReadOFF[33]}
N 240 -8630 320 -8630 {lab=rowReadON[33]}
N 240 -8170 320 -8170 {lab=rowReadOFF[34]}
N 240 -8150 320 -8150 {lab=rowReadON[34]}
N 240 -8130 320 -8130 {lab=rowReadOFF[35]}
N 240 -8110 320 -8110 {lab=rowReadON[35]}
N 240 -7650 320 -7650 {lab=rowReadOFF[36]}
N 240 -7630 320 -7630 {lab=rowReadON[36]}
N 240 -7610 320 -7610 {lab=rowReadOFF[37]}
N 240 -7590 320 -7590 {lab=rowReadON[37]}
N 240 -7130 320 -7130 {lab=rowReadOFF[38]}
N 240 -7110 320 -7110 {lab=rowReadON[38]}
N 240 -7090 320 -7090 {lab=rowReadOFF[39]}
N 240 -7070 320 -7070 {lab=rowReadON[39]}
N 240 -6610 320 -6610 {lab=rowReadOFF[40]}
N 240 -6590 320 -6590 {lab=rowReadON[40]}
N 240 -6570 320 -6570 {lab=rowReadOFF[41]}
N 240 -6550 320 -6550 {lab=rowReadON[41]}
N 240 -6090 320 -6090 {lab=rowReadOFF[42]}
N 240 -6070 320 -6070 {lab=rowReadON[42]}
N 240 -6050 320 -6050 {lab=rowReadOFF[43]}
N 240 -6030 320 -6030 {lab=rowReadON[43]}
N 240 -5570 320 -5570 {lab=rowReadOFF[44]}
N 240 -5550 320 -5550 {lab=rowReadON[44]}
N 240 -5530 320 -5530 {lab=rowReadOFF[45]}
N 240 -5510 320 -5510 {lab=rowReadON[45]}
N 240 -5050 320 -5050 {lab=rowReadOFF[46]}
N 240 -5030 320 -5030 {lab=rowReadON[46]}
N 240 -5010 320 -5010 {lab=rowReadOFF[47]}
N 240 -4990 320 -4990 {lab=rowReadON[47]}
N 240 -4530 320 -4530 {lab=rowReadOFF[48]}
N 240 -4510 320 -4510 {lab=rowReadON[48]}
N 240 -4490 320 -4490 {lab=rowReadOFF[49]}
N 240 -4470 320 -4470 {lab=rowReadON[49]}
N 240 -4010 320 -4010 {lab=rowReadOFF[50]}
N 240 -3990 320 -3990 {lab=rowReadON[50]}
N 240 -3970 320 -3970 {lab=rowReadOFF[51]}
N 240 -3950 320 -3950 {lab=rowReadON[51]}
N 240 -3490 320 -3490 {lab=rowReadOFF[52]}
N 240 -3470 320 -3470 {lab=rowReadON[52]}
N 240 -3450 320 -3450 {lab=rowReadOFF[53]}
N 240 -3430 320 -3430 {lab=rowReadON[53]}
N 240 -2970 320 -2970 {lab=rowReadOFF[54]}
N 240 -2950 320 -2950 {lab=rowReadON[54]}
N 240 -2930 320 -2930 {lab=rowReadOFF[55]}
N 240 -2910 320 -2910 {lab=rowReadON[55]}
N 240 -2450 320 -2450 {lab=rowReadOFF[56]}
N 240 -2430 320 -2430 {lab=rowReadON[56]}
N 240 -2410 320 -2410 {lab=rowReadOFF[57]}
N 240 -2390 320 -2390 {lab=rowReadON[57]}
N 240 -1930 320 -1930 {lab=rowReadOFF[58]}
N 240 -1910 320 -1910 {lab=rowReadON[58]}
N 240 -1890 320 -1890 {lab=rowReadOFF[59]}
N 240 -1870 320 -1870 {lab=rowReadON[59]}
N 240 -1410 320 -1410 {lab=rowReadON[60]}
N 240 -1390 320 -1390 {lab=rowReadOFF[60]}
N 240 -1370 320 -1370 {lab=rowReadOFF[61]}
N 240 -1350 320 -1350 {lab=rowReadON[61]}
N 240 -890 320 -890 {lab=rowReadOFF[62]}
N 240 -870 320 -870 {lab=rowReadON[62]}
N 240 -850 320 -850 {lab=rowReadOFF[63]}
N 240 -830 320 -830 {lab=rowReadON[63]}
N 470 -17450 470 -17380 {lab=DiffBn}
N 490 -17450 490 -17380 {lab=RefrBp}
N 510 -17450 510 -17380 {lab=PrSFBp}
N 530 -17450 530 -17380 {lab=OffBn}
N 550 -17450 550 -17380 {lab=PrBp}
N 570 -17450 570 -17380 {lab=OnBn}
N 410 -17450 410 -17380 {lab=VDD}
N 450 -17450 450 -17380 {lab=GndD}
N 430 -17450 430 -17380 {lab=GndA}
N 240 -600 320 -600 {lab=GndD}
N 240 -580 320 -580 {lab=VDD}
N 240 -560 320 -560 {lab=nCHARGE}
C {iopin.sym} -100 -300 0 0 {name=p12 lab=GndA}
C {iopin.sym} -100 -270 0 0 {name=p13 lab=VDD}
C {iopin.sym} -100 -80 0 0 {name=p57 lab=OffBn}
C {iopin.sym} -100 -100 0 0 {name=p58 lab=OnBn}
C {iopin.sym} -100 -120 0 0 {name=p59 lab=DiffBn}
C {iopin.sym} -100 -140 0 0 {name=p60 lab=RefrBp}
C {iopin.sym} -100 -160 0 0 {name=p61 lab=PrSFBp}
C {iopin.sym} -100 -180 0 0 {name=p62 lab=PrBp}
C {iopin.sym} -210 -300 0 0 {name=p14 lab=NCHARGE}
C {iopin.sym} -210 -270 0 0 {name=p281 lab=VTHRESH}
C {iopin.sym} -320 -300 0 0 {name=p282 lab=nDETECT}
C {iopin.sym} -320 -270 0 0 {name=p283 lab=DETECT}
C {iopin.sym} -320 -180 0 0 {name=p284 lab=rowReadON[63:0]}
C {iopin.sym} -320 -160 0 0 {name=p285 lab=rowReadOFF[63:0]}
C {iopin.sym} -320 -140 0 0 {name=p286 lab=pixRst[63:0]}
C {iopin.sym} -320 -120 0 0 {name=p287 lab=voutn[63:0]}
C {col_amp_2x1.sym} 340 -720 2 1 {name=x1024}
C {col_amp_2x1.sym} 680 -720 2 1 {name=x1025}
C {col_amp_2x1.sym} 1020 -720 2 1 {name=x1026}
C {col_amp_2x1.sym} 1360 -720 2 1 {name=x1027}
C {col_amp_2x1.sym} 1700 -720 2 1 {name=x1028}
C {col_amp_2x1.sym} 2040 -720 2 1 {name=x1029}
C {col_amp_2x1.sym} 2380 -720 2 1 {name=x1030}
C {col_amp_2x1.sym} 2720 -720 2 1 {name=x1031}
C {col_amp_2x1.sym} 3060 -720 2 1 {name=x1032}
C {col_amp_2x1.sym} 3400 -720 2 1 {name=x1033}
C {col_amp_2x1.sym} 3740 -720 2 1 {name=x1034}
C {col_amp_2x1.sym} 4080 -720 2 1 {name=x1035}
C {col_amp_2x1.sym} 4420 -720 2 1 {name=x1036}
C {col_amp_2x1.sym} 4760 -720 2 1 {name=x1037}
C {col_amp_2x1.sym} 5100 -720 2 1 {name=x1038}
C {col_amp_2x1.sym} 5440 -720 2 1 {name=x1039}
C {col_amp_2x1.sym} 5780 -720 2 1 {name=x1040}
C {col_amp_2x1.sym} 6120 -720 2 1 {name=x1041}
C {col_amp_2x1.sym} 6460 -720 2 1 {name=x1042}
C {col_amp_2x1.sym} 6800 -720 2 1 {name=x1043}
C {col_amp_2x1.sym} 7140 -720 2 1 {name=x1044}
C {col_amp_2x1.sym} 7480 -720 2 1 {name=x1045}
C {col_amp_2x1.sym} 7820 -720 2 1 {name=x1046}
C {col_amp_2x1.sym} 8160 -720 2 1 {name=x1047}
C {col_amp_2x1.sym} 8500 -720 2 1 {name=x1048}
C {col_amp_2x1.sym} 8840 -720 2 1 {name=x1049}
C {col_amp_2x1.sym} 9180 -720 2 1 {name=x1050}
C {col_amp_2x1.sym} 9520 -720 2 1 {name=x1051}
C {col_amp_2x1.sym} 9860 -720 2 1 {name=x1052}
C {col_amp_2x1.sym} 10200 -720 2 1 {name=x1053}
C {col_amp_2x1.sym} 10540 -720 2 1 {name=x1054}
C {col_amp_2x1.sym} 10880 -720 2 1 {name=x1055}
C {lab_wire.sym} 260 -540 2 1 {name=p291 sig_type=std_logic lab=VTHRESH}
C {lab_wire.sym} 260 -520 2 1 {name=p292 sig_type=std_logic lab=nDETECT}
C {lab_wire.sym} 260 -500 2 1 {name=p293 sig_type=std_logic lab=DETECT}
C {lab_wire.sym} 11140 -370 1 1 {name=p294 sig_type=std_logic lab=pixRst[0]}
C {lab_wire.sym} 10900 -370 1 1 {name=p295 sig_type=std_logic lab=pixRst[1]}
C {lab_wire.sym} 11080 -370 1 1 {name=p296 sig_type=std_logic lab=voutn[0]}
C {lab_wire.sym} 10960 -370 1 1 {name=p297 sig_type=std_logic lab=voutn[1]}
C {lab_wire.sym} 10800 -370 1 1 {name=p298 sig_type=std_logic lab=pixRst[2]}
C {lab_wire.sym} 10560 -370 1 1 {name=p299 sig_type=std_logic lab=pixRst[3]}
C {lab_wire.sym} 10740 -370 1 1 {name=p300 sig_type=std_logic lab=voutn[2]}
C {lab_wire.sym} 10620 -370 1 1 {name=p301 sig_type=std_logic lab=voutn[3]}
C {lab_wire.sym} 10460 -370 1 1 {name=p302 sig_type=std_logic lab=pixRst[4]}
C {lab_wire.sym} 10220 -370 1 1 {name=p303 sig_type=std_logic lab=pixRst[5]}
C {lab_wire.sym} 10400 -370 1 1 {name=p304 sig_type=std_logic lab=voutn[4]}
C {lab_wire.sym} 10280 -370 1 1 {name=p305 sig_type=std_logic lab=voutn[5]}
C {lab_wire.sym} 10120 -370 1 1 {name=p306 sig_type=std_logic lab=pixRst[6]}
C {lab_wire.sym} 9880 -370 1 1 {name=p307 sig_type=std_logic lab=pixRst[7]}
C {lab_wire.sym} 10060 -370 1 1 {name=p308 sig_type=std_logic lab=voutn[6]}
C {lab_wire.sym} 9940 -370 1 1 {name=p309 sig_type=std_logic lab=voutn[7]}
C {lab_wire.sym} 9780 -370 1 1 {name=p310 sig_type=std_logic lab=pixRst[8]}
C {lab_wire.sym} 9540 -370 1 1 {name=p311 sig_type=std_logic lab=pixRst[9]}
C {lab_wire.sym} 9720 -370 1 1 {name=p312 sig_type=std_logic lab=voutn[8]}
C {lab_wire.sym} 9600 -370 1 1 {name=p313 sig_type=std_logic lab=voutn[9]}
C {lab_wire.sym} 9440 -370 1 1 {name=p314 sig_type=std_logic lab=pixRst[10]}
C {lab_wire.sym} 9200 -370 1 1 {name=p315 sig_type=std_logic lab=pixRst[11]}
C {lab_wire.sym} 9380 -370 1 1 {name=p316 sig_type=std_logic lab=voutn[10]}
C {lab_wire.sym} 9260 -370 1 1 {name=p317 sig_type=std_logic lab=voutn[11]}
C {lab_wire.sym} 9100 -370 1 1 {name=p318 sig_type=std_logic lab=pixRst[12]}
C {lab_wire.sym} 8860 -370 1 1 {name=p319 sig_type=std_logic lab=pixRst[13]}
C {lab_wire.sym} 9040 -370 1 1 {name=p320 sig_type=std_logic lab=voutn[12]}
C {lab_wire.sym} 8920 -370 1 1 {name=p321 sig_type=std_logic lab=voutn[13]}
C {lab_wire.sym} 8760 -370 1 1 {name=p322 sig_type=std_logic lab=pixRst[14]}
C {lab_wire.sym} 8520 -370 1 1 {name=p323 sig_type=std_logic lab=pixRst[15]}
C {lab_wire.sym} 8700 -370 1 1 {name=p324 sig_type=std_logic lab=voutn[14]}
C {lab_wire.sym} 8580 -370 1 1 {name=p325 sig_type=std_logic lab=voutn[15]}
C {lab_wire.sym} 8420 -370 1 1 {name=p326 sig_type=std_logic lab=pixRst[16]}
C {lab_wire.sym} 8180 -370 1 1 {name=p327 sig_type=std_logic lab=pixRst[17]}
C {lab_wire.sym} 8360 -370 1 1 {name=p328 sig_type=std_logic lab=voutn[16]}
C {lab_wire.sym} 8240 -370 1 1 {name=p329 sig_type=std_logic lab=voutn[17]}
C {lab_wire.sym} 8080 -370 1 1 {name=p330 sig_type=std_logic lab=pixRst[18]}
C {lab_wire.sym} 7840 -370 1 1 {name=p331 sig_type=std_logic lab=pixRst[19]}
C {lab_wire.sym} 8020 -370 1 1 {name=p332 sig_type=std_logic lab=voutn[18]}
C {lab_wire.sym} 7900 -370 1 1 {name=p333 sig_type=std_logic lab=voutn[19]}
C {lab_wire.sym} 7740 -370 1 1 {name=p334 sig_type=std_logic lab=pixRst[20]}
C {lab_wire.sym} 7500 -370 1 1 {name=p335 sig_type=std_logic lab=pixRst[21]}
C {lab_wire.sym} 7680 -370 1 1 {name=p336 sig_type=std_logic lab=voutn[20]}
C {lab_wire.sym} 7560 -370 1 1 {name=p337 sig_type=std_logic lab=voutn[21]}
C {lab_wire.sym} 7400 -370 1 1 {name=p338 sig_type=std_logic lab=pixRst[22]}
C {lab_wire.sym} 7160 -370 1 1 {name=p339 sig_type=std_logic lab=pixRst[23]}
C {lab_wire.sym} 7340 -370 1 1 {name=p340 sig_type=std_logic lab=voutn[22]}
C {lab_wire.sym} 7220 -370 1 1 {name=p341 sig_type=std_logic lab=voutn[23]}
C {lab_wire.sym} 7060 -370 1 1 {name=p342 sig_type=std_logic lab=pixRst[24]}
C {lab_wire.sym} 6820 -370 1 1 {name=p343 sig_type=std_logic lab=pixRst[25]}
C {lab_wire.sym} 7000 -370 1 1 {name=p344 sig_type=std_logic lab=voutn[24]}
C {lab_wire.sym} 6880 -370 1 1 {name=p345 sig_type=std_logic lab=voutn[25]}
C {lab_wire.sym} 6720 -370 1 1 {name=p346 sig_type=std_logic lab=pixRst[26]}
C {lab_wire.sym} 6480 -370 1 1 {name=p347 sig_type=std_logic lab=pixRst[27]}
C {lab_wire.sym} 6660 -370 1 1 {name=p348 sig_type=std_logic lab=voutn[26]}
C {lab_wire.sym} 6540 -370 1 1 {name=p349 sig_type=std_logic lab=voutn[27]}
C {lab_wire.sym} 6380 -370 1 1 {name=p350 sig_type=std_logic lab=pixRst[28]}
C {lab_wire.sym} 6140 -370 1 1 {name=p351 sig_type=std_logic lab=pixRst[29]}
C {lab_wire.sym} 6320 -370 1 1 {name=p352 sig_type=std_logic lab=voutn[28]}
C {lab_wire.sym} 6200 -370 1 1 {name=p353 sig_type=std_logic lab=voutn[29]}
C {lab_wire.sym} 6040 -370 1 1 {name=p354 sig_type=std_logic lab=pixRst[30]}
C {lab_wire.sym} 5800 -370 1 1 {name=p355 sig_type=std_logic lab=pixRst[31]}
C {lab_wire.sym} 5980 -370 1 1 {name=p356 sig_type=std_logic lab=voutn[30]}
C {lab_wire.sym} 5860 -370 1 1 {name=p357 sig_type=std_logic lab=voutn[31]}
C {lab_wire.sym} 5700 -370 1 1 {name=p358 sig_type=std_logic lab=pixRst[32]}
C {lab_wire.sym} 5460 -370 1 1 {name=p359 sig_type=std_logic lab=pixRst[33]}
C {lab_wire.sym} 5640 -370 1 1 {name=p360 sig_type=std_logic lab=voutn[32]}
C {lab_wire.sym} 5520 -370 1 1 {name=p361 sig_type=std_logic lab=voutn[33]}
C {lab_wire.sym} 5360 -370 1 1 {name=p362 sig_type=std_logic lab=pixRst[34]}
C {lab_wire.sym} 5120 -370 1 1 {name=p363 sig_type=std_logic lab=pixRst[35]}
C {lab_wire.sym} 5300 -370 1 1 {name=p364 sig_type=std_logic lab=voutn[34]}
C {lab_wire.sym} 5180 -370 1 1 {name=p365 sig_type=std_logic lab=voutn[35]}
C {lab_wire.sym} 5020 -370 1 1 {name=p366 sig_type=std_logic lab=pixRst[36]}
C {lab_wire.sym} 4780 -370 1 1 {name=p367 sig_type=std_logic lab=pixRst[37]}
C {lab_wire.sym} 4960 -370 1 1 {name=p368 sig_type=std_logic lab=voutn[36]}
C {lab_wire.sym} 4840 -370 1 1 {name=p369 sig_type=std_logic lab=voutn[37]}
C {lab_wire.sym} 4680 -370 1 1 {name=p370 sig_type=std_logic lab=pixRst[38]}
C {lab_wire.sym} 4440 -370 1 1 {name=p371 sig_type=std_logic lab=pixRst[39]}
C {lab_wire.sym} 4620 -370 1 1 {name=p372 sig_type=std_logic lab=voutn[38]}
C {lab_wire.sym} 4500 -370 1 1 {name=p373 sig_type=std_logic lab=voutn[39]}
C {lab_wire.sym} 4340 -370 1 1 {name=p374 sig_type=std_logic lab=pixRst[40]}
C {lab_wire.sym} 4100 -370 1 1 {name=p375 sig_type=std_logic lab=pixRst[41]}
C {lab_wire.sym} 4280 -370 1 1 {name=p376 sig_type=std_logic lab=voutn[40]}
C {lab_wire.sym} 4160 -370 1 1 {name=p377 sig_type=std_logic lab=voutn[41]}
C {lab_wire.sym} 4000 -370 1 1 {name=p378 sig_type=std_logic lab=pixRst[42]}
C {lab_wire.sym} 3760 -370 1 1 {name=p379 sig_type=std_logic lab=pixRst[43]}
C {lab_wire.sym} 3940 -370 1 1 {name=p380 sig_type=std_logic lab=voutn[42]}
C {lab_wire.sym} 3820 -370 1 1 {name=p381 sig_type=std_logic lab=voutn[43]}
C {lab_wire.sym} 3660 -370 1 1 {name=p382 sig_type=std_logic lab=pixRst[44]}
C {lab_wire.sym} 3420 -370 1 1 {name=p383 sig_type=std_logic lab=pixRst[45]}
C {lab_wire.sym} 3600 -370 1 1 {name=p384 sig_type=std_logic lab=voutn[44]}
C {lab_wire.sym} 3480 -370 1 1 {name=p385 sig_type=std_logic lab=voutn[45]}
C {lab_wire.sym} 3320 -370 1 1 {name=p386 sig_type=std_logic lab=pixRst[46]}
C {lab_wire.sym} 3080 -370 1 1 {name=p387 sig_type=std_logic lab=pixRst[47]}
C {lab_wire.sym} 3260 -370 1 1 {name=p388 sig_type=std_logic lab=voutn[46]}
C {lab_wire.sym} 3140 -370 1 1 {name=p389 sig_type=std_logic lab=voutn[47]}
C {lab_wire.sym} 2980 -370 1 1 {name=p390 sig_type=std_logic lab=pixRst[48]}
C {lab_wire.sym} 2740 -370 1 1 {name=p391 sig_type=std_logic lab=pixRst[49]}
C {lab_wire.sym} 2920 -370 1 1 {name=p392 sig_type=std_logic lab=voutn[48]}
C {lab_wire.sym} 2800 -370 1 1 {name=p393 sig_type=std_logic lab=voutn[49]}
C {lab_wire.sym} 2640 -370 1 1 {name=p394 sig_type=std_logic lab=pixRst[50]}
C {lab_wire.sym} 2400 -370 1 1 {name=p395 sig_type=std_logic lab=pixRst[51]}
C {lab_wire.sym} 2580 -370 1 1 {name=p396 sig_type=std_logic lab=voutn[50]}
C {lab_wire.sym} 2460 -370 1 1 {name=p397 sig_type=std_logic lab=voutn[51]}
C {lab_wire.sym} 2300 -370 1 1 {name=p398 sig_type=std_logic lab=pixRst[52]}
C {lab_wire.sym} 2060 -370 1 1 {name=p399 sig_type=std_logic lab=pixRst[53]}
C {lab_wire.sym} 2240 -370 1 1 {name=p400 sig_type=std_logic lab=voutn[52]}
C {lab_wire.sym} 2120 -370 1 1 {name=p401 sig_type=std_logic lab=voutn[53]}
C {lab_wire.sym} 1960 -370 1 1 {name=p402 sig_type=std_logic lab=pixRst[54]}
C {lab_wire.sym} 1720 -370 1 1 {name=p403 sig_type=std_logic lab=pixRst[55]}
C {lab_wire.sym} 1900 -370 1 1 {name=p404 sig_type=std_logic lab=voutn[54]}
C {lab_wire.sym} 1780 -370 1 1 {name=p405 sig_type=std_logic lab=voutn[55]}
C {lab_wire.sym} 1620 -370 1 1 {name=p406 sig_type=std_logic lab=pixRst[56]}
C {lab_wire.sym} 1380 -370 1 1 {name=p407 sig_type=std_logic lab=pixRst[57]}
C {lab_wire.sym} 1560 -370 1 1 {name=p408 sig_type=std_logic lab=voutn[56]}
C {lab_wire.sym} 1440 -370 1 1 {name=p409 sig_type=std_logic lab=voutn[57]}
C {lab_wire.sym} 1280 -370 1 1 {name=p410 sig_type=std_logic lab=pixRst[58]}
C {lab_wire.sym} 1040 -370 1 1 {name=p411 sig_type=std_logic lab=pixRst[59]}
C {lab_wire.sym} 1220 -370 1 1 {name=p412 sig_type=std_logic lab=voutn[58]}
C {lab_wire.sym} 1100 -370 1 1 {name=p413 sig_type=std_logic lab=voutn[59]}
C {lab_wire.sym} 940 -370 1 1 {name=p414 sig_type=std_logic lab=pixRst[60]}
C {lab_wire.sym} 700 -370 1 1 {name=p415 sig_type=std_logic lab=pixRst[61]}
C {lab_wire.sym} 880 -370 1 1 {name=p416 sig_type=std_logic lab=voutn[60]}
C {lab_wire.sym} 760 -370 1 1 {name=p417 sig_type=std_logic lab=voutn[61]}
C {lab_wire.sym} 600 -370 1 1 {name=p418 sig_type=std_logic lab=pixRst[62]}
C {lab_wire.sym} 360 -370 1 1 {name=p419 sig_type=std_logic lab=pixRst[63]}
C {lab_wire.sym} 540 -370 1 1 {name=p420 sig_type=std_logic lab=voutn[62]}
C {lab_wire.sym} 420 -370 1 1 {name=p421 sig_type=std_logic lab=voutn[63]}
C {lab_wire.sym} 260 -17010 0 0 {name=p156 sig_type=std_logic lab=rowReadOFF[0]}
C {lab_wire.sym} 260 -16990 0 0 {name=p157 sig_type=std_logic lab=rowReadON[0]}
C {lab_wire.sym} 260 -16970 0 0 {name=p158 sig_type=std_logic lab=rowReadOFF[1]}
C {lab_wire.sym} 260 -16950 0 0 {name=p159 sig_type=std_logic lab=rowReadON[1]}
C {lab_wire.sym} 260 -16490 0 0 {name=p160 sig_type=std_logic lab=rowReadOFF[2]}
C {lab_wire.sym} 260 -16470 0 0 {name=p161 sig_type=std_logic lab=rowReadON[2]}
C {lab_wire.sym} 260 -16450 0 0 {name=p162 sig_type=std_logic lab=rowReadOFF[3]}
C {lab_wire.sym} 260 -16430 0 0 {name=p163 sig_type=std_logic lab=rowReadON[3]}
C {lab_wire.sym} 260 -15970 0 0 {name=p164 sig_type=std_logic lab=rowReadOFF[4]}
C {lab_wire.sym} 260 -15950 0 0 {name=p165 sig_type=std_logic lab=rowReadON[4]}
C {lab_wire.sym} 260 -15930 0 0 {name=p166 sig_type=std_logic lab=rowReadOFF[5]}
C {lab_wire.sym} 260 -15910 0 0 {name=p167 sig_type=std_logic lab=rowReadON[5]}
C {lab_wire.sym} 260 -15450 0 0 {name=p168 sig_type=std_logic lab=rowReadOFF[6]}
C {lab_wire.sym} 260 -15430 0 0 {name=p169 sig_type=std_logic lab=rowReadON[6]}
C {lab_wire.sym} 260 -15410 0 0 {name=p170 sig_type=std_logic lab=rowReadOFF[7]}
C {lab_wire.sym} 260 -15390 0 0 {name=p171 sig_type=std_logic lab=rowReadON[7]}
C {lab_wire.sym} 260 -14930 0 0 {name=p172 sig_type=std_logic lab=rowReadOFF[8]}
C {lab_wire.sym} 260 -14910 0 0 {name=p173 sig_type=std_logic lab=rowReadON[8]}
C {lab_wire.sym} 260 -14890 0 0 {name=p174 sig_type=std_logic lab=rowReadOFF[9]}
C {lab_wire.sym} 260 -14870 0 0 {name=p175 sig_type=std_logic lab=rowReadON[9]}
C {lab_wire.sym} 260 -14410 0 0 {name=p176 sig_type=std_logic lab=rowReadOFF[10]}
C {lab_wire.sym} 260 -14390 0 0 {name=p177 sig_type=std_logic lab=rowReadON[10]}
C {lab_wire.sym} 260 -14370 0 0 {name=p178 sig_type=std_logic lab=rowReadOFF[11]}
C {lab_wire.sym} 260 -14350 0 0 {name=p179 sig_type=std_logic lab=rowReadON[11]}
C {lab_wire.sym} 260 -13890 0 0 {name=p180 sig_type=std_logic lab=rowReadOFF[12]}
C {lab_wire.sym} 260 -13870 0 0 {name=p181 sig_type=std_logic lab=rowReadON[12]}
C {lab_wire.sym} 260 -13850 0 0 {name=p182 sig_type=std_logic lab=rowReadOFF[13]}
C {lab_wire.sym} 260 -13830 0 0 {name=p183 sig_type=std_logic lab=rowReadON[13]}
C {lab_wire.sym} 260 -13370 0 0 {name=p184 sig_type=std_logic lab=rowReadOFF[14]}
C {lab_wire.sym} 260 -13350 0 0 {name=p185 sig_type=std_logic lab=rowReadON[14]}
C {lab_wire.sym} 260 -13330 0 0 {name=p186 sig_type=std_logic lab=rowReadOFF[15]}
C {lab_wire.sym} 260 -13310 0 0 {name=p187 sig_type=std_logic lab=rowReadON[15]}
C {lab_wire.sym} 260 -12850 0 0 {name=p188 sig_type=std_logic lab=rowReadOFF[16]}
C {lab_wire.sym} 260 -12830 0 0 {name=p189 sig_type=std_logic lab=rowReadON[16]}
C {lab_wire.sym} 260 -12810 0 0 {name=p190 sig_type=std_logic lab=rowReadOFF[17]}
C {lab_wire.sym} 260 -12790 0 0 {name=p191 sig_type=std_logic lab=rowReadON[17]}
C {lab_wire.sym} 260 -12310 0 0 {name=p192 sig_type=std_logic lab=rowReadON[18]}
C {lab_wire.sym} 260 -12330 0 0 {name=p193 sig_type=std_logic lab=rowReadOFF[18]}
C {lab_wire.sym} 260 -12290 0 0 {name=p194 sig_type=std_logic lab=rowReadOFF[19]}
C {lab_wire.sym} 260 -12270 0 0 {name=p195 sig_type=std_logic lab=rowReadON[19]}
C {lab_wire.sym} 260 -11790 0 0 {name=p196 sig_type=std_logic lab=rowReadON[20]}
C {lab_wire.sym} 260 -11810 0 0 {name=p197 sig_type=std_logic lab=rowReadOFF[20]}
C {lab_wire.sym} 260 -11750 0 0 {name=p198 sig_type=std_logic lab=rowReadON[21]}
C {lab_wire.sym} 260 -11770 0 0 {name=p199 sig_type=std_logic lab=rowReadOFF[21]}
C {lab_wire.sym} 260 -11270 0 0 {name=p200 sig_type=std_logic lab=rowReadON[22]}
C {lab_wire.sym} 260 -11290 0 0 {name=p201 sig_type=std_logic lab=rowReadOFF[22]}
C {lab_wire.sym} 260 -11230 0 0 {name=p202 sig_type=std_logic lab=rowReadON[23]}
C {lab_wire.sym} 260 -11250 0 0 {name=p203 sig_type=std_logic lab=rowReadOFF[23]}
C {lab_wire.sym} 260 -10770 0 0 {name=p205 sig_type=std_logic lab=rowReadOFF[24]}
C {lab_wire.sym} 260 -10710 0 0 {name=p206 sig_type=std_logic lab=rowReadON[25]}
C {lab_wire.sym} 260 -10730 0 0 {name=p207 sig_type=std_logic lab=rowReadOFF[25]}
C {lab_wire.sym} 260 -10230 0 0 {name=p208 sig_type=std_logic lab=rowReadON[26]}
C {lab_wire.sym} 260 -10250 0 0 {name=p209 sig_type=std_logic lab=rowReadOFF[26]}
C {lab_wire.sym} 260 -10190 0 0 {name=p210 sig_type=std_logic lab=rowReadON[27]}
C {lab_wire.sym} 260 -10210 0 0 {name=p211 sig_type=std_logic lab=rowReadOFF[27]}
C {lab_wire.sym} 260 -9710 0 0 {name=p212 sig_type=std_logic lab=rowReadON[28]}
C {lab_wire.sym} 260 -9730 0 0 {name=p213 sig_type=std_logic lab=rowReadOFF[28]}
C {lab_wire.sym} 260 -9670 0 0 {name=p214 sig_type=std_logic lab=rowReadON[29]}
C {lab_wire.sym} 260 -9690 0 0 {name=p215 sig_type=std_logic lab=rowReadOFF[29]}
C {lab_wire.sym} 260 -9190 0 0 {name=p216 sig_type=std_logic lab=rowReadON[30]}
C {lab_wire.sym} 260 -9210 0 0 {name=p217 sig_type=std_logic lab=rowReadOFF[30]}
C {lab_wire.sym} 260 -9150 0 0 {name=p218 sig_type=std_logic lab=rowReadON[31]}
C {lab_wire.sym} 260 -9170 0 0 {name=p219 sig_type=std_logic lab=rowReadOFF[31]}
C {lab_wire.sym} 260 -8670 0 0 {name=p220 sig_type=std_logic lab=rowReadON[32]}
C {lab_wire.sym} 260 -8690 0 0 {name=p221 sig_type=std_logic lab=rowReadOFF[32]}
C {lab_wire.sym} 260 -8630 0 0 {name=p222 sig_type=std_logic lab=rowReadON[33]}
C {lab_wire.sym} 260 -8650 0 0 {name=p223 sig_type=std_logic lab=rowReadOFF[33]}
C {lab_wire.sym} 260 -8150 0 0 {name=p224 sig_type=std_logic lab=rowReadON[34]}
C {lab_wire.sym} 260 -8170 0 0 {name=p225 sig_type=std_logic lab=rowReadOFF[34]}
C {lab_wire.sym} 260 -8110 0 0 {name=p226 sig_type=std_logic lab=rowReadON[35]}
C {lab_wire.sym} 260 -8130 0 0 {name=p227 sig_type=std_logic lab=rowReadOFF[35]}
C {lab_wire.sym} 260 -7630 0 0 {name=p228 sig_type=std_logic lab=rowReadON[36]}
C {lab_wire.sym} 260 -7650 0 0 {name=p229 sig_type=std_logic lab=rowReadOFF[36]}
C {lab_wire.sym} 260 -7590 0 0 {name=p230 sig_type=std_logic lab=rowReadON[37]}
C {lab_wire.sym} 260 -7610 0 0 {name=p231 sig_type=std_logic lab=rowReadOFF[37]}
C {lab_wire.sym} 260 -7110 0 0 {name=p232 sig_type=std_logic lab=rowReadON[38]}
C {lab_wire.sym} 260 -7130 0 0 {name=p233 sig_type=std_logic lab=rowReadOFF[38]}
C {lab_wire.sym} 260 -7070 0 0 {name=p234 sig_type=std_logic lab=rowReadON[39]}
C {lab_wire.sym} 260 -7090 0 0 {name=p235 sig_type=std_logic lab=rowReadOFF[39]}
C {lab_wire.sym} 260 -6590 0 0 {name=p236 sig_type=std_logic lab=rowReadON[40]}
C {lab_wire.sym} 260 -6610 0 0 {name=p237 sig_type=std_logic lab=rowReadOFF[40]}
C {lab_wire.sym} 260 -6550 0 0 {name=p238 sig_type=std_logic lab=rowReadON[41]}
C {lab_wire.sym} 260 -6570 0 0 {name=p239 sig_type=std_logic lab=rowReadOFF[41]}
C {lab_wire.sym} 260 -6070 0 0 {name=p240 sig_type=std_logic lab=rowReadON[42]}
C {lab_wire.sym} 260 -6090 0 0 {name=p241 sig_type=std_logic lab=rowReadOFF[42]}
C {lab_wire.sym} 260 -6030 0 0 {name=p242 sig_type=std_logic lab=rowReadON[43]}
C {lab_wire.sym} 260 -6050 0 0 {name=p243 sig_type=std_logic lab=rowReadOFF[43]}
C {lab_wire.sym} 260 -5550 0 0 {name=p244 sig_type=std_logic lab=rowReadON[44]}
C {lab_wire.sym} 260 -5570 0 0 {name=p245 sig_type=std_logic lab=rowReadOFF[44]}
C {lab_wire.sym} 260 -5510 0 0 {name=p246 sig_type=std_logic lab=rowReadON[45]}
C {lab_wire.sym} 260 -5530 0 0 {name=p247 sig_type=std_logic lab=rowReadOFF[45]}
C {lab_wire.sym} 260 -5030 0 0 {name=p248 sig_type=std_logic lab=rowReadON[46]}
C {lab_wire.sym} 260 -5050 0 0 {name=p249 sig_type=std_logic lab=rowReadOFF[46]}
C {lab_wire.sym} 260 -4990 0 0 {name=p250 sig_type=std_logic lab=rowReadON[47]}
C {lab_wire.sym} 260 -5010 0 0 {name=p251 sig_type=std_logic lab=rowReadOFF[47]}
C {lab_wire.sym} 260 -4510 0 0 {name=p252 sig_type=std_logic lab=rowReadON[48]}
C {lab_wire.sym} 260 -4530 0 0 {name=p253 sig_type=std_logic lab=rowReadOFF[48]}
C {lab_wire.sym} 260 -4470 0 0 {name=p254 sig_type=std_logic lab=rowReadON[49]}
C {lab_wire.sym} 260 -4490 0 0 {name=p255 sig_type=std_logic lab=rowReadOFF[49]}
C {lab_wire.sym} 260 -3990 0 0 {name=p256 sig_type=std_logic lab=rowReadON[50]}
C {lab_wire.sym} 260 -4010 0 0 {name=p257 sig_type=std_logic lab=rowReadOFF[50]}
C {lab_wire.sym} 260 -3950 0 0 {name=p258 sig_type=std_logic lab=rowReadON[51]}
C {lab_wire.sym} 260 -3970 0 0 {name=p259 sig_type=std_logic lab=rowReadOFF[51]}
C {lab_wire.sym} 260 -3470 0 0 {name=p260 sig_type=std_logic lab=rowReadON[52]}
C {lab_wire.sym} 260 -3490 0 0 {name=p261 sig_type=std_logic lab=rowReadOFF[52]}
C {lab_wire.sym} 260 -3430 0 0 {name=p262 sig_type=std_logic lab=rowReadON[53]}
C {lab_wire.sym} 260 -3450 0 0 {name=p263 sig_type=std_logic lab=rowReadOFF[53]}
C {lab_wire.sym} 260 -2950 0 0 {name=p264 sig_type=std_logic lab=rowReadON[54]}
C {lab_wire.sym} 260 -2970 0 0 {name=p265 sig_type=std_logic lab=rowReadOFF[54]}
C {lab_wire.sym} 260 -2910 0 0 {name=p266 sig_type=std_logic lab=rowReadON[55]}
C {lab_wire.sym} 260 -2930 0 0 {name=p267 sig_type=std_logic lab=rowReadOFF[55]}
C {lab_wire.sym} 260 -2430 0 0 {name=p268 sig_type=std_logic lab=rowReadON[56]}
C {lab_wire.sym} 260 -2450 0 0 {name=p269 sig_type=std_logic lab=rowReadOFF[56]}
C {lab_wire.sym} 260 -2390 0 0 {name=p270 sig_type=std_logic lab=rowReadON[57]}
C {lab_wire.sym} 260 -2410 0 0 {name=p271 sig_type=std_logic lab=rowReadOFF[57]}
C {lab_wire.sym} 260 -1910 0 0 {name=p272 sig_type=std_logic lab=rowReadON[58]}
C {lab_wire.sym} 260 -1930 0 0 {name=p273 sig_type=std_logic lab=rowReadOFF[58]}
C {lab_wire.sym} 260 -1870 0 0 {name=p274 sig_type=std_logic lab=rowReadON[59]}
C {lab_wire.sym} 260 -1890 0 0 {name=p275 sig_type=std_logic lab=rowReadOFF[59]}
C {lab_wire.sym} 260 -1410 0 0 {name=p276 sig_type=std_logic lab=rowReadON[60]}
C {lab_wire.sym} 260 -1390 0 0 {name=p277 sig_type=std_logic lab=rowReadOFF[60]}
C {lab_wire.sym} 260 -1350 0 0 {name=p278 sig_type=std_logic lab=rowReadON[61]}
C {lab_wire.sym} 260 -1370 0 0 {name=p279 sig_type=std_logic lab=rowReadOFF[61]}
C {lab_wire.sym} 260 -870 0 0 {name=p280 sig_type=std_logic lab=rowReadON[62]}
C {lab_wire.sym} 260 -890 0 0 {name=p422 sig_type=std_logic lab=rowReadOFF[62]}
C {lab_wire.sym} 260 -830 0 0 {name=p423 sig_type=std_logic lab=rowReadON[63]}
C {lab_wire.sym} 260 -850 0 0 {name=p424 sig_type=std_logic lab=rowReadOFF[63]}
C {lab_wire.sym} 260 -10750 0 0 {name=p1 sig_type=std_logic lab=rowReadON[24]}
C {lab_wire.sym} 470 -17420 3 1 {name=p2 sig_type=std_logic lab=DiffBn}
C {lab_wire.sym} 490 -17420 3 1 {name=p3 sig_type=std_logic lab=RefrBp}
C {lab_wire.sym} 510 -17420 3 1 {name=p4 sig_type=std_logic lab=PrSFBp}
C {lab_wire.sym} 530 -17420 3 1 {name=p5 sig_type=std_logic lab=OffBn}
C {lab_wire.sym} 550 -17420 3 1 {name=p6 sig_type=std_logic lab=PrBp}
C {lab_wire.sym} 570 -17420 3 1 {name=p7 sig_type=std_logic lab=OnBn}
C {lab_wire.sym} 410 -17420 3 1 {name=p8 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 450 -17420 3 1 {name=p9 sig_type=std_logic lab=GndD}
C {lab_wire.sym} 430 -17420 3 1 {name=p10 sig_type=std_logic lab=GndA}
C {lab_wire.sym} 260 -600 2 1 {name=p288 sig_type=std_logic lab=GndA}
C {lab_wire.sym} 260 -580 2 1 {name=p289 sig_type=std_logic lab=VDD}
C {lab_wire.sym} 260 -560 2 1 {name=p290 sig_type=std_logic lab=NCHARGE}
C {iopin.sym} -100 -340 0 0 {name=p11 lab=GndD}
C {openDVS_pixel2x2_bot.sym} 490 -17090 0 0 {name=x1}
C {openDVS_pixel2x2_bot.sym} 830 -17090 0 0 {name=x2}
C {openDVS_pixel2x2_bot.sym} 1170 -17090 0 0 {name=x3}
C {openDVS_pixel2x2_bot.sym} 1510 -17090 0 0 {name=x4}
C {openDVS_pixel2x2_bot.sym} 1850 -17090 0 0 {name=x5}
C {openDVS_pixel2x2_bot.sym} 2190 -17090 0 0 {name=x6}
C {openDVS_pixel2x2_bot.sym} 2530 -17090 0 0 {name=x7}
C {openDVS_pixel2x2_bot.sym} 2870 -17090 0 0 {name=x8}
C {openDVS_pixel2x2_bot.sym} 3210 -17090 0 0 {name=x9}
C {openDVS_pixel2x2_bot.sym} 3550 -17090 0 0 {name=x10}
C {openDVS_pixel2x2_bot.sym} 3890 -17090 0 0 {name=x11}
C {openDVS_pixel2x2_bot.sym} 4230 -17090 0 0 {name=x12}
C {openDVS_pixel2x2_bot.sym} 4570 -17090 0 0 {name=x13}
C {openDVS_pixel2x2_bot.sym} 4910 -17090 0 0 {name=x14}
C {openDVS_pixel2x2_bot.sym} 5250 -17090 0 0 {name=x15}
C {openDVS_pixel2x2_bot.sym} 5590 -17090 0 0 {name=x16}
C {openDVS_pixel2x2_bot.sym} 5930 -17090 0 0 {name=x17}
C {openDVS_pixel2x2_bot.sym} 6270 -17090 0 0 {name=x18}
C {openDVS_pixel2x2_bot.sym} 6610 -17090 0 0 {name=x19}
C {openDVS_pixel2x2_bot.sym} 6950 -17090 0 0 {name=x20}
C {openDVS_pixel2x2_bot.sym} 7290 -17090 0 0 {name=x21}
C {openDVS_pixel2x2_bot.sym} 7630 -17090 0 0 {name=x22}
C {openDVS_pixel2x2_bot.sym} 7970 -17090 0 0 {name=x23}
C {openDVS_pixel2x2_bot.sym} 8310 -17090 0 0 {name=x24}
C {openDVS_pixel2x2_bot.sym} 8650 -17090 0 0 {name=x25}
C {openDVS_pixel2x2_bot.sym} 8990 -17090 0 0 {name=x26}
C {openDVS_pixel2x2_bot.sym} 9330 -17090 0 0 {name=x27}
C {openDVS_pixel2x2_bot.sym} 9670 -17090 0 0 {name=x28}
C {openDVS_pixel2x2_bot.sym} 10010 -17090 0 0 {name=x29}
C {openDVS_pixel2x2_bot.sym} 10350 -17090 0 0 {name=x30}
C {openDVS_pixel2x2_bot.sym} 10690 -17090 0 0 {name=x31}
C {openDVS_pixel2x2_bot.sym} 11030 -17090 0 0 {name=x32}
C {openDVS_pixel2x2_bot.sym} 490 -16570 0 0 {name=x1056}
C {openDVS_pixel2x2_bot.sym} 830 -16570 0 0 {name=x1057}
C {openDVS_pixel2x2_bot.sym} 1170 -16570 0 0 {name=x1058}
C {openDVS_pixel2x2_bot.sym} 1510 -16570 0 0 {name=x1059}
C {openDVS_pixel2x2_bot.sym} 1850 -16570 0 0 {name=x1060}
C {openDVS_pixel2x2_bot.sym} 2190 -16570 0 0 {name=x1061}
C {openDVS_pixel2x2_bot.sym} 2530 -16570 0 0 {name=x1062}
C {openDVS_pixel2x2_bot.sym} 2870 -16570 0 0 {name=x1063}
C {openDVS_pixel2x2_bot.sym} 3210 -16570 0 0 {name=x1064}
C {openDVS_pixel2x2_bot.sym} 3550 -16570 0 0 {name=x1065}
C {openDVS_pixel2x2_bot.sym} 3890 -16570 0 0 {name=x1066}
C {openDVS_pixel2x2_bot.sym} 4230 -16570 0 0 {name=x1067}
C {openDVS_pixel2x2_bot.sym} 4570 -16570 0 0 {name=x1068}
C {openDVS_pixel2x2_bot.sym} 4910 -16570 0 0 {name=x1069}
C {openDVS_pixel2x2_bot.sym} 5250 -16570 0 0 {name=x1070}
C {openDVS_pixel2x2_bot.sym} 5590 -16570 0 0 {name=x1071}
C {openDVS_pixel2x2_bot.sym} 5930 -16570 0 0 {name=x1072}
C {openDVS_pixel2x2_bot.sym} 6270 -16570 0 0 {name=x1073}
C {openDVS_pixel2x2_bot.sym} 6610 -16570 0 0 {name=x1074}
C {openDVS_pixel2x2_bot.sym} 6950 -16570 0 0 {name=x1075}
C {openDVS_pixel2x2_bot.sym} 7290 -16570 0 0 {name=x1076}
C {openDVS_pixel2x2_bot.sym} 7630 -16570 0 0 {name=x1077}
C {openDVS_pixel2x2_bot.sym} 7970 -16570 0 0 {name=x1078}
C {openDVS_pixel2x2_bot.sym} 8310 -16570 0 0 {name=x1079}
C {openDVS_pixel2x2_bot.sym} 8650 -16570 0 0 {name=x1080}
C {openDVS_pixel2x2_bot.sym} 8990 -16570 0 0 {name=x1081}
C {openDVS_pixel2x2_bot.sym} 9330 -16570 0 0 {name=x1082}
C {openDVS_pixel2x2_bot.sym} 9670 -16570 0 0 {name=x1083}
C {openDVS_pixel2x2_bot.sym} 10010 -16570 0 0 {name=x1084}
C {openDVS_pixel2x2_bot.sym} 10350 -16570 0 0 {name=x1085}
C {openDVS_pixel2x2_bot.sym} 10690 -16570 0 0 {name=x1086}
C {openDVS_pixel2x2_bot.sym} 11030 -16570 0 0 {name=x1087}
C {openDVS_pixel2x2_bot.sym} 490 -16050 0 0 {name=x1120}
C {openDVS_pixel2x2_bot.sym} 830 -16050 0 0 {name=x1121}
C {openDVS_pixel2x2_bot.sym} 1170 -16050 0 0 {name=x1122}
C {openDVS_pixel2x2_bot.sym} 1510 -16050 0 0 {name=x1123}
C {openDVS_pixel2x2_bot.sym} 1850 -16050 0 0 {name=x1124}
C {openDVS_pixel2x2_bot.sym} 2190 -16050 0 0 {name=x1125}
C {openDVS_pixel2x2_bot.sym} 2530 -16050 0 0 {name=x1126}
C {openDVS_pixel2x2_bot.sym} 2870 -16050 0 0 {name=x1127}
C {openDVS_pixel2x2_bot.sym} 3210 -16050 0 0 {name=x1128}
C {openDVS_pixel2x2_bot.sym} 3550 -16050 0 0 {name=x1129}
C {openDVS_pixel2x2_bot.sym} 3890 -16050 0 0 {name=x1130}
C {openDVS_pixel2x2_bot.sym} 4230 -16050 0 0 {name=x1131}
C {openDVS_pixel2x2_bot.sym} 4570 -16050 0 0 {name=x1132}
C {openDVS_pixel2x2_bot.sym} 4910 -16050 0 0 {name=x1133}
C {openDVS_pixel2x2_bot.sym} 5250 -16050 0 0 {name=x1134}
C {openDVS_pixel2x2_bot.sym} 5590 -16050 0 0 {name=x1135}
C {openDVS_pixel2x2_bot.sym} 5930 -16050 0 0 {name=x1136}
C {openDVS_pixel2x2_bot.sym} 6270 -16050 0 0 {name=x1137}
C {openDVS_pixel2x2_bot.sym} 6610 -16050 0 0 {name=x1138}
C {openDVS_pixel2x2_bot.sym} 6950 -16050 0 0 {name=x1139}
C {openDVS_pixel2x2_bot.sym} 7290 -16050 0 0 {name=x1140}
C {openDVS_pixel2x2_bot.sym} 7630 -16050 0 0 {name=x1141}
C {openDVS_pixel2x2_bot.sym} 7970 -16050 0 0 {name=x1142}
C {openDVS_pixel2x2_bot.sym} 8310 -16050 0 0 {name=x1143}
C {openDVS_pixel2x2_bot.sym} 8650 -16050 0 0 {name=x1144}
C {openDVS_pixel2x2_bot.sym} 8990 -16050 0 0 {name=x1145}
C {openDVS_pixel2x2_bot.sym} 9330 -16050 0 0 {name=x1146}
C {openDVS_pixel2x2_bot.sym} 9670 -16050 0 0 {name=x1147}
C {openDVS_pixel2x2_bot.sym} 10010 -16050 0 0 {name=x1148}
C {openDVS_pixel2x2_bot.sym} 10350 -16050 0 0 {name=x1149}
C {openDVS_pixel2x2_bot.sym} 10690 -16050 0 0 {name=x1150}
C {openDVS_pixel2x2_bot.sym} 11030 -16050 0 0 {name=x1151}
C {openDVS_pixel2x2_bot.sym} 490 -15530 0 0 {name=x1152}
C {openDVS_pixel2x2_bot.sym} 830 -15530 0 0 {name=x1153}
C {openDVS_pixel2x2_bot.sym} 1170 -15530 0 0 {name=x1154}
C {openDVS_pixel2x2_bot.sym} 1510 -15530 0 0 {name=x1155}
C {openDVS_pixel2x2_bot.sym} 1850 -15530 0 0 {name=x1156}
C {openDVS_pixel2x2_bot.sym} 2190 -15530 0 0 {name=x1157}
C {openDVS_pixel2x2_bot.sym} 2530 -15530 0 0 {name=x1158}
C {openDVS_pixel2x2_bot.sym} 2870 -15530 0 0 {name=x1159}
C {openDVS_pixel2x2_bot.sym} 3210 -15530 0 0 {name=x1160}
C {openDVS_pixel2x2_bot.sym} 3550 -15530 0 0 {name=x1161}
C {openDVS_pixel2x2_bot.sym} 3890 -15530 0 0 {name=x1162}
C {openDVS_pixel2x2_bot.sym} 4230 -15530 0 0 {name=x1163}
C {openDVS_pixel2x2_bot.sym} 4570 -15530 0 0 {name=x1164}
C {openDVS_pixel2x2_bot.sym} 4910 -15530 0 0 {name=x1165}
C {openDVS_pixel2x2_bot.sym} 5250 -15530 0 0 {name=x1166}
C {openDVS_pixel2x2_bot.sym} 5590 -15530 0 0 {name=x1167}
C {openDVS_pixel2x2_bot.sym} 5930 -15530 0 0 {name=x1168}
C {openDVS_pixel2x2_bot.sym} 6270 -15530 0 0 {name=x1169}
C {openDVS_pixel2x2_bot.sym} 6610 -15530 0 0 {name=x1170}
C {openDVS_pixel2x2_bot.sym} 6950 -15530 0 0 {name=x1171}
C {openDVS_pixel2x2_bot.sym} 7290 -15530 0 0 {name=x1172}
C {openDVS_pixel2x2_bot.sym} 7630 -15530 0 0 {name=x1173}
C {openDVS_pixel2x2_bot.sym} 7970 -15530 0 0 {name=x1174}
C {openDVS_pixel2x2_bot.sym} 8310 -15530 0 0 {name=x1175}
C {openDVS_pixel2x2_bot.sym} 8650 -15530 0 0 {name=x1176}
C {openDVS_pixel2x2_bot.sym} 8990 -15530 0 0 {name=x1177}
C {openDVS_pixel2x2_bot.sym} 9330 -15530 0 0 {name=x1178}
C {openDVS_pixel2x2_bot.sym} 9670 -15530 0 0 {name=x1179}
C {openDVS_pixel2x2_bot.sym} 10010 -15530 0 0 {name=x1180}
C {openDVS_pixel2x2_bot.sym} 10350 -15530 0 0 {name=x1181}
C {openDVS_pixel2x2_bot.sym} 10690 -15530 0 0 {name=x1182}
C {openDVS_pixel2x2_bot.sym} 11030 -15530 0 0 {name=x1183}
C {openDVS_pixel2x2_bot.sym} 490 -15010 0 0 {name=x1184}
C {openDVS_pixel2x2_bot.sym} 830 -15010 0 0 {name=x1185}
C {openDVS_pixel2x2_bot.sym} 1170 -15010 0 0 {name=x1186}
C {openDVS_pixel2x2_bot.sym} 1510 -15010 0 0 {name=x1187}
C {openDVS_pixel2x2_bot.sym} 1850 -15010 0 0 {name=x1188}
C {openDVS_pixel2x2_bot.sym} 2190 -15010 0 0 {name=x1189}
C {openDVS_pixel2x2_bot.sym} 2530 -15010 0 0 {name=x1190}
C {openDVS_pixel2x2_bot.sym} 2870 -15010 0 0 {name=x1191}
C {openDVS_pixel2x2_bot.sym} 3210 -15010 0 0 {name=x1192}
C {openDVS_pixel2x2_bot.sym} 3550 -15010 0 0 {name=x1193}
C {openDVS_pixel2x2_bot.sym} 3890 -15010 0 0 {name=x1194}
C {openDVS_pixel2x2_bot.sym} 4230 -15010 0 0 {name=x1195}
C {openDVS_pixel2x2_bot.sym} 4570 -15010 0 0 {name=x1196}
C {openDVS_pixel2x2_bot.sym} 4910 -15010 0 0 {name=x1197}
C {openDVS_pixel2x2_bot.sym} 5250 -15010 0 0 {name=x1198}
C {openDVS_pixel2x2_bot.sym} 5590 -15010 0 0 {name=x1199}
C {openDVS_pixel2x2_bot.sym} 5930 -15010 0 0 {name=x1200}
C {openDVS_pixel2x2_bot.sym} 6270 -15010 0 0 {name=x1201}
C {openDVS_pixel2x2_bot.sym} 6610 -15010 0 0 {name=x1202}
C {openDVS_pixel2x2_bot.sym} 6950 -15010 0 0 {name=x1203}
C {openDVS_pixel2x2_bot.sym} 7290 -15010 0 0 {name=x1204}
C {openDVS_pixel2x2_bot.sym} 7630 -15010 0 0 {name=x1205}
C {openDVS_pixel2x2_bot.sym} 7970 -15010 0 0 {name=x1206}
C {openDVS_pixel2x2_bot.sym} 8310 -15010 0 0 {name=x1207}
C {openDVS_pixel2x2_bot.sym} 8650 -15010 0 0 {name=x1208}
C {openDVS_pixel2x2_bot.sym} 8990 -15010 0 0 {name=x1209}
C {openDVS_pixel2x2_bot.sym} 9330 -15010 0 0 {name=x1210}
C {openDVS_pixel2x2_bot.sym} 9670 -15010 0 0 {name=x1211}
C {openDVS_pixel2x2_bot.sym} 10010 -15010 0 0 {name=x1212}
C {openDVS_pixel2x2_bot.sym} 10350 -15010 0 0 {name=x1213}
C {openDVS_pixel2x2_bot.sym} 10690 -15010 0 0 {name=x1214}
C {openDVS_pixel2x2_bot.sym} 11030 -15010 0 0 {name=x1215}
C {openDVS_pixel2x2_bot.sym} 490 -14490 0 0 {name=x1216}
C {openDVS_pixel2x2_bot.sym} 830 -14490 0 0 {name=x1217}
C {openDVS_pixel2x2_bot.sym} 1170 -14490 0 0 {name=x1218}
C {openDVS_pixel2x2_bot.sym} 1510 -14490 0 0 {name=x1219}
C {openDVS_pixel2x2_bot.sym} 1850 -14490 0 0 {name=x1220}
C {openDVS_pixel2x2_bot.sym} 2190 -14490 0 0 {name=x1221}
C {openDVS_pixel2x2_bot.sym} 2530 -14490 0 0 {name=x1222}
C {openDVS_pixel2x2_bot.sym} 2870 -14490 0 0 {name=x1223}
C {openDVS_pixel2x2_bot.sym} 3210 -14490 0 0 {name=x1224}
C {openDVS_pixel2x2_bot.sym} 3550 -14490 0 0 {name=x1225}
C {openDVS_pixel2x2_bot.sym} 3890 -14490 0 0 {name=x1226}
C {openDVS_pixel2x2_bot.sym} 4230 -14490 0 0 {name=x1227}
C {openDVS_pixel2x2_bot.sym} 4570 -14490 0 0 {name=x1228}
C {openDVS_pixel2x2_bot.sym} 4910 -14490 0 0 {name=x1229}
C {openDVS_pixel2x2_bot.sym} 5250 -14490 0 0 {name=x1230}
C {openDVS_pixel2x2_bot.sym} 5590 -14490 0 0 {name=x1231}
C {openDVS_pixel2x2_bot.sym} 5930 -14490 0 0 {name=x1232}
C {openDVS_pixel2x2_bot.sym} 6270 -14490 0 0 {name=x1233}
C {openDVS_pixel2x2_bot.sym} 6610 -14490 0 0 {name=x1234}
C {openDVS_pixel2x2_bot.sym} 6950 -14490 0 0 {name=x1235}
C {openDVS_pixel2x2_bot.sym} 7290 -14490 0 0 {name=x1236}
C {openDVS_pixel2x2_bot.sym} 7630 -14490 0 0 {name=x1237}
C {openDVS_pixel2x2_bot.sym} 7970 -14490 0 0 {name=x1238}
C {openDVS_pixel2x2_bot.sym} 8310 -14490 0 0 {name=x1239}
C {openDVS_pixel2x2_bot.sym} 8650 -14490 0 0 {name=x1240}
C {openDVS_pixel2x2_bot.sym} 8990 -14490 0 0 {name=x1241}
C {openDVS_pixel2x2_bot.sym} 9330 -14490 0 0 {name=x1242}
C {openDVS_pixel2x2_bot.sym} 9670 -14490 0 0 {name=x1243}
C {openDVS_pixel2x2_bot.sym} 10010 -14490 0 0 {name=x1244}
C {openDVS_pixel2x2_bot.sym} 10350 -14490 0 0 {name=x1245}
C {openDVS_pixel2x2_bot.sym} 10690 -14490 0 0 {name=x1246}
C {openDVS_pixel2x2_bot.sym} 11030 -14490 0 0 {name=x1247}
C {openDVS_pixel2x2_bot.sym} 490 -13970 0 0 {name=x1248}
C {openDVS_pixel2x2_bot.sym} 830 -13970 0 0 {name=x1249}
C {openDVS_pixel2x2_bot.sym} 1170 -13970 0 0 {name=x1250}
C {openDVS_pixel2x2_bot.sym} 1510 -13970 0 0 {name=x1251}
C {openDVS_pixel2x2_bot.sym} 1850 -13970 0 0 {name=x1252}
C {openDVS_pixel2x2_bot.sym} 2190 -13970 0 0 {name=x1253}
C {openDVS_pixel2x2_bot.sym} 2530 -13970 0 0 {name=x1254}
C {openDVS_pixel2x2_bot.sym} 2870 -13970 0 0 {name=x1255}
C {openDVS_pixel2x2_bot.sym} 3210 -13970 0 0 {name=x1256}
C {openDVS_pixel2x2_bot.sym} 3550 -13970 0 0 {name=x1257}
C {openDVS_pixel2x2_bot.sym} 3890 -13970 0 0 {name=x1258}
C {openDVS_pixel2x2_bot.sym} 4230 -13970 0 0 {name=x1259}
C {openDVS_pixel2x2_bot.sym} 4570 -13970 0 0 {name=x1260}
C {openDVS_pixel2x2_bot.sym} 4910 -13970 0 0 {name=x1261}
C {openDVS_pixel2x2_bot.sym} 5250 -13970 0 0 {name=x1262}
C {openDVS_pixel2x2_bot.sym} 5590 -13970 0 0 {name=x1263}
C {openDVS_pixel2x2_bot.sym} 5930 -13970 0 0 {name=x1264}
C {openDVS_pixel2x2_bot.sym} 6270 -13970 0 0 {name=x1265}
C {openDVS_pixel2x2_bot.sym} 6610 -13970 0 0 {name=x1266}
C {openDVS_pixel2x2_bot.sym} 6950 -13970 0 0 {name=x1267}
C {openDVS_pixel2x2_bot.sym} 7290 -13970 0 0 {name=x1268}
C {openDVS_pixel2x2_bot.sym} 7630 -13970 0 0 {name=x1269}
C {openDVS_pixel2x2_bot.sym} 7970 -13970 0 0 {name=x1270}
C {openDVS_pixel2x2_bot.sym} 8310 -13970 0 0 {name=x1271}
C {openDVS_pixel2x2_bot.sym} 8650 -13970 0 0 {name=x1272}
C {openDVS_pixel2x2_bot.sym} 8990 -13970 0 0 {name=x1273}
C {openDVS_pixel2x2_bot.sym} 9330 -13970 0 0 {name=x1274}
C {openDVS_pixel2x2_bot.sym} 9670 -13970 0 0 {name=x1275}
C {openDVS_pixel2x2_bot.sym} 10010 -13970 0 0 {name=x1276}
C {openDVS_pixel2x2_bot.sym} 10350 -13970 0 0 {name=x1277}
C {openDVS_pixel2x2_bot.sym} 10690 -13970 0 0 {name=x1278}
C {openDVS_pixel2x2_bot.sym} 11030 -13970 0 0 {name=x1279}
C {openDVS_pixel2x2_bot.sym} 490 -13450 0 0 {name=x1280}
C {openDVS_pixel2x2_bot.sym} 830 -13450 0 0 {name=x1281}
C {openDVS_pixel2x2_bot.sym} 1170 -13450 0 0 {name=x1282}
C {openDVS_pixel2x2_bot.sym} 1510 -13450 0 0 {name=x1283}
C {openDVS_pixel2x2_bot.sym} 1850 -13450 0 0 {name=x1284}
C {openDVS_pixel2x2_bot.sym} 2190 -13450 0 0 {name=x1285}
C {openDVS_pixel2x2_bot.sym} 2530 -13450 0 0 {name=x1286}
C {openDVS_pixel2x2_bot.sym} 2870 -13450 0 0 {name=x1287}
C {openDVS_pixel2x2_bot.sym} 3210 -13450 0 0 {name=x1288}
C {openDVS_pixel2x2_bot.sym} 3550 -13450 0 0 {name=x1289}
C {openDVS_pixel2x2_bot.sym} 3890 -13450 0 0 {name=x1290}
C {openDVS_pixel2x2_bot.sym} 4230 -13450 0 0 {name=x1291}
C {openDVS_pixel2x2_bot.sym} 4570 -13450 0 0 {name=x1292}
C {openDVS_pixel2x2_bot.sym} 4910 -13450 0 0 {name=x1293}
C {openDVS_pixel2x2_bot.sym} 5250 -13450 0 0 {name=x1294}
C {openDVS_pixel2x2_bot.sym} 5590 -13450 0 0 {name=x1295}
C {openDVS_pixel2x2_bot.sym} 5930 -13450 0 0 {name=x1296}
C {openDVS_pixel2x2_bot.sym} 6270 -13450 0 0 {name=x1297}
C {openDVS_pixel2x2_bot.sym} 6610 -13450 0 0 {name=x1298}
C {openDVS_pixel2x2_bot.sym} 6950 -13450 0 0 {name=x1299}
C {openDVS_pixel2x2_bot.sym} 7290 -13450 0 0 {name=x1300}
C {openDVS_pixel2x2_bot.sym} 7630 -13450 0 0 {name=x1301}
C {openDVS_pixel2x2_bot.sym} 7970 -13450 0 0 {name=x1302}
C {openDVS_pixel2x2_bot.sym} 8310 -13450 0 0 {name=x1303}
C {openDVS_pixel2x2_bot.sym} 8650 -13450 0 0 {name=x1304}
C {openDVS_pixel2x2_bot.sym} 8990 -13450 0 0 {name=x1305}
C {openDVS_pixel2x2_bot.sym} 9330 -13450 0 0 {name=x1306}
C {openDVS_pixel2x2_bot.sym} 9670 -13450 0 0 {name=x1307}
C {openDVS_pixel2x2_bot.sym} 10010 -13450 0 0 {name=x1308}
C {openDVS_pixel2x2_bot.sym} 10350 -13450 0 0 {name=x1309}
C {openDVS_pixel2x2_bot.sym} 10690 -13450 0 0 {name=x1310}
C {openDVS_pixel2x2_bot.sym} 11030 -13450 0 0 {name=x1311}
C {openDVS_pixel2x2_bot.sym} 490 -12930 0 0 {name=x1312}
C {openDVS_pixel2x2_bot.sym} 830 -12930 0 0 {name=x1313}
C {openDVS_pixel2x2_bot.sym} 1170 -12930 0 0 {name=x1314}
C {openDVS_pixel2x2_bot.sym} 1510 -12930 0 0 {name=x1315}
C {openDVS_pixel2x2_bot.sym} 1850 -12930 0 0 {name=x1316}
C {openDVS_pixel2x2_bot.sym} 2190 -12930 0 0 {name=x1317}
C {openDVS_pixel2x2_bot.sym} 2530 -12930 0 0 {name=x1318}
C {openDVS_pixel2x2_bot.sym} 2870 -12930 0 0 {name=x1319}
C {openDVS_pixel2x2_bot.sym} 3210 -12930 0 0 {name=x1320}
C {openDVS_pixel2x2_bot.sym} 3550 -12930 0 0 {name=x1321}
C {openDVS_pixel2x2_bot.sym} 3890 -12930 0 0 {name=x1322}
C {openDVS_pixel2x2_bot.sym} 4230 -12930 0 0 {name=x1323}
C {openDVS_pixel2x2_bot.sym} 4570 -12930 0 0 {name=x1324}
C {openDVS_pixel2x2_bot.sym} 4910 -12930 0 0 {name=x1325}
C {openDVS_pixel2x2_bot.sym} 5250 -12930 0 0 {name=x1326}
C {openDVS_pixel2x2_bot.sym} 5590 -12930 0 0 {name=x1327}
C {openDVS_pixel2x2_bot.sym} 5930 -12930 0 0 {name=x1328}
C {openDVS_pixel2x2_bot.sym} 6270 -12930 0 0 {name=x1329}
C {openDVS_pixel2x2_bot.sym} 6610 -12930 0 0 {name=x1330}
C {openDVS_pixel2x2_bot.sym} 6950 -12930 0 0 {name=x1331}
C {openDVS_pixel2x2_bot.sym} 7290 -12930 0 0 {name=x1332}
C {openDVS_pixel2x2_bot.sym} 7630 -12930 0 0 {name=x1333}
C {openDVS_pixel2x2_bot.sym} 7970 -12930 0 0 {name=x1334}
C {openDVS_pixel2x2_bot.sym} 8310 -12930 0 0 {name=x1335}
C {openDVS_pixel2x2_bot.sym} 8650 -12930 0 0 {name=x1336}
C {openDVS_pixel2x2_bot.sym} 8990 -12930 0 0 {name=x1337}
C {openDVS_pixel2x2_bot.sym} 9330 -12930 0 0 {name=x1338}
C {openDVS_pixel2x2_bot.sym} 9670 -12930 0 0 {name=x1339}
C {openDVS_pixel2x2_bot.sym} 10010 -12930 0 0 {name=x1340}
C {openDVS_pixel2x2_bot.sym} 10350 -12930 0 0 {name=x1341}
C {openDVS_pixel2x2_bot.sym} 10690 -12930 0 0 {name=x1342}
C {openDVS_pixel2x2_bot.sym} 11030 -12930 0 0 {name=x1343}
C {openDVS_pixel2x2_bot.sym} 490 -12410 0 0 {name=x1344}
C {openDVS_pixel2x2_bot.sym} 830 -12410 0 0 {name=x1345}
C {openDVS_pixel2x2_bot.sym} 1170 -12410 0 0 {name=x1346}
C {openDVS_pixel2x2_bot.sym} 1510 -12410 0 0 {name=x1347}
C {openDVS_pixel2x2_bot.sym} 1850 -12410 0 0 {name=x1348}
C {openDVS_pixel2x2_bot.sym} 2190 -12410 0 0 {name=x1349}
C {openDVS_pixel2x2_bot.sym} 2530 -12410 0 0 {name=x1350}
C {openDVS_pixel2x2_bot.sym} 2870 -12410 0 0 {name=x1351}
C {openDVS_pixel2x2_bot.sym} 3210 -12410 0 0 {name=x1352}
C {openDVS_pixel2x2_bot.sym} 3550 -12410 0 0 {name=x1353}
C {openDVS_pixel2x2_bot.sym} 3890 -12410 0 0 {name=x1354}
C {openDVS_pixel2x2_bot.sym} 4230 -12410 0 0 {name=x1355}
C {openDVS_pixel2x2_bot.sym} 4570 -12410 0 0 {name=x1356}
C {openDVS_pixel2x2_bot.sym} 4910 -12410 0 0 {name=x1357}
C {openDVS_pixel2x2_bot.sym} 5250 -12410 0 0 {name=x1358}
C {openDVS_pixel2x2_bot.sym} 5590 -12410 0 0 {name=x1359}
C {openDVS_pixel2x2_bot.sym} 5930 -12410 0 0 {name=x1360}
C {openDVS_pixel2x2_bot.sym} 6270 -12410 0 0 {name=x1361}
C {openDVS_pixel2x2_bot.sym} 6610 -12410 0 0 {name=x1362}
C {openDVS_pixel2x2_bot.sym} 6950 -12410 0 0 {name=x1363}
C {openDVS_pixel2x2_bot.sym} 7290 -12410 0 0 {name=x1364}
C {openDVS_pixel2x2_bot.sym} 7630 -12410 0 0 {name=x1365}
C {openDVS_pixel2x2_bot.sym} 7970 -12410 0 0 {name=x1366}
C {openDVS_pixel2x2_bot.sym} 8310 -12410 0 0 {name=x1367}
C {openDVS_pixel2x2_bot.sym} 8650 -12410 0 0 {name=x1368}
C {openDVS_pixel2x2_bot.sym} 8990 -12410 0 0 {name=x1369}
C {openDVS_pixel2x2_bot.sym} 9330 -12410 0 0 {name=x1370}
C {openDVS_pixel2x2_bot.sym} 9670 -12410 0 0 {name=x1371}
C {openDVS_pixel2x2_bot.sym} 10010 -12410 0 0 {name=x1372}
C {openDVS_pixel2x2_bot.sym} 10350 -12410 0 0 {name=x1373}
C {openDVS_pixel2x2_bot.sym} 10690 -12410 0 0 {name=x1374}
C {openDVS_pixel2x2_bot.sym} 11030 -12410 0 0 {name=x1375}
C {openDVS_pixel2x2_bot.sym} 490 -11890 0 0 {name=x1376}
C {openDVS_pixel2x2_bot.sym} 830 -11890 0 0 {name=x1377}
C {openDVS_pixel2x2_bot.sym} 1170 -11890 0 0 {name=x1378}
C {openDVS_pixel2x2_bot.sym} 1510 -11890 0 0 {name=x1379}
C {openDVS_pixel2x2_bot.sym} 1850 -11890 0 0 {name=x1380}
C {openDVS_pixel2x2_bot.sym} 2190 -11890 0 0 {name=x1381}
C {openDVS_pixel2x2_bot.sym} 2530 -11890 0 0 {name=x1382}
C {openDVS_pixel2x2_bot.sym} 2870 -11890 0 0 {name=x1383}
C {openDVS_pixel2x2_bot.sym} 3210 -11890 0 0 {name=x1384}
C {openDVS_pixel2x2_bot.sym} 3550 -11890 0 0 {name=x1385}
C {openDVS_pixel2x2_bot.sym} 3890 -11890 0 0 {name=x1386}
C {openDVS_pixel2x2_bot.sym} 4230 -11890 0 0 {name=x1387}
C {openDVS_pixel2x2_bot.sym} 4570 -11890 0 0 {name=x1388}
C {openDVS_pixel2x2_bot.sym} 4910 -11890 0 0 {name=x1389}
C {openDVS_pixel2x2_bot.sym} 5250 -11890 0 0 {name=x1390}
C {openDVS_pixel2x2_bot.sym} 5590 -11890 0 0 {name=x1391}
C {openDVS_pixel2x2_bot.sym} 5930 -11890 0 0 {name=x1392}
C {openDVS_pixel2x2_bot.sym} 6270 -11890 0 0 {name=x1393}
C {openDVS_pixel2x2_bot.sym} 6610 -11890 0 0 {name=x1394}
C {openDVS_pixel2x2_bot.sym} 6950 -11890 0 0 {name=x1395}
C {openDVS_pixel2x2_bot.sym} 7290 -11890 0 0 {name=x1396}
C {openDVS_pixel2x2_bot.sym} 7630 -11890 0 0 {name=x1397}
C {openDVS_pixel2x2_bot.sym} 7970 -11890 0 0 {name=x1398}
C {openDVS_pixel2x2_bot.sym} 8310 -11890 0 0 {name=x1399}
C {openDVS_pixel2x2_bot.sym} 8650 -11890 0 0 {name=x1400}
C {openDVS_pixel2x2_bot.sym} 8990 -11890 0 0 {name=x1401}
C {openDVS_pixel2x2_bot.sym} 9330 -11890 0 0 {name=x1402}
C {openDVS_pixel2x2_bot.sym} 9670 -11890 0 0 {name=x1403}
C {openDVS_pixel2x2_bot.sym} 10010 -11890 0 0 {name=x1404}
C {openDVS_pixel2x2_bot.sym} 10350 -11890 0 0 {name=x1405}
C {openDVS_pixel2x2_bot.sym} 10690 -11890 0 0 {name=x1406}
C {openDVS_pixel2x2_bot.sym} 11030 -11890 0 0 {name=x1407}
C {openDVS_pixel2x2_bot.sym} 490 -11370 0 0 {name=x1408}
C {openDVS_pixel2x2_bot.sym} 830 -11370 0 0 {name=x1409}
C {openDVS_pixel2x2_bot.sym} 1170 -11370 0 0 {name=x1410}
C {openDVS_pixel2x2_bot.sym} 1510 -11370 0 0 {name=x1411}
C {openDVS_pixel2x2_bot.sym} 1850 -11370 0 0 {name=x1412}
C {openDVS_pixel2x2_bot.sym} 2190 -11370 0 0 {name=x1413}
C {openDVS_pixel2x2_bot.sym} 2530 -11370 0 0 {name=x1414}
C {openDVS_pixel2x2_bot.sym} 2870 -11370 0 0 {name=x1415}
C {openDVS_pixel2x2_bot.sym} 3210 -11370 0 0 {name=x1416}
C {openDVS_pixel2x2_bot.sym} 3550 -11370 0 0 {name=x1417}
C {openDVS_pixel2x2_bot.sym} 3890 -11370 0 0 {name=x1418}
C {openDVS_pixel2x2_bot.sym} 4230 -11370 0 0 {name=x1419}
C {openDVS_pixel2x2_bot.sym} 4570 -11370 0 0 {name=x1420}
C {openDVS_pixel2x2_bot.sym} 4910 -11370 0 0 {name=x1421}
C {openDVS_pixel2x2_bot.sym} 5250 -11370 0 0 {name=x1422}
C {openDVS_pixel2x2_bot.sym} 5590 -11370 0 0 {name=x1423}
C {openDVS_pixel2x2_bot.sym} 5930 -11370 0 0 {name=x1424}
C {openDVS_pixel2x2_bot.sym} 6270 -11370 0 0 {name=x1425}
C {openDVS_pixel2x2_bot.sym} 6610 -11370 0 0 {name=x1426}
C {openDVS_pixel2x2_bot.sym} 6950 -11370 0 0 {name=x1427}
C {openDVS_pixel2x2_bot.sym} 7290 -11370 0 0 {name=x1428}
C {openDVS_pixel2x2_bot.sym} 7630 -11370 0 0 {name=x1429}
C {openDVS_pixel2x2_bot.sym} 7970 -11370 0 0 {name=x1430}
C {openDVS_pixel2x2_bot.sym} 8310 -11370 0 0 {name=x1431}
C {openDVS_pixel2x2_bot.sym} 8650 -11370 0 0 {name=x1432}
C {openDVS_pixel2x2_bot.sym} 8990 -11370 0 0 {name=x1433}
C {openDVS_pixel2x2_bot.sym} 9330 -11370 0 0 {name=x1434}
C {openDVS_pixel2x2_bot.sym} 9670 -11370 0 0 {name=x1435}
C {openDVS_pixel2x2_bot.sym} 10010 -11370 0 0 {name=x1436}
C {openDVS_pixel2x2_bot.sym} 10350 -11370 0 0 {name=x1437}
C {openDVS_pixel2x2_bot.sym} 10690 -11370 0 0 {name=x1438}
C {openDVS_pixel2x2_bot.sym} 11030 -11370 0 0 {name=x1439}
C {openDVS_pixel2x2_bot.sym} 490 -10850 0 0 {name=x1440}
C {openDVS_pixel2x2_bot.sym} 830 -10850 0 0 {name=x1441}
C {openDVS_pixel2x2_bot.sym} 1170 -10850 0 0 {name=x1442}
C {openDVS_pixel2x2_bot.sym} 1510 -10850 0 0 {name=x1443}
C {openDVS_pixel2x2_bot.sym} 1850 -10850 0 0 {name=x1444}
C {openDVS_pixel2x2_bot.sym} 2190 -10850 0 0 {name=x1445}
C {openDVS_pixel2x2_bot.sym} 2530 -10850 0 0 {name=x1446}
C {openDVS_pixel2x2_bot.sym} 2870 -10850 0 0 {name=x1447}
C {openDVS_pixel2x2_bot.sym} 3210 -10850 0 0 {name=x1448}
C {openDVS_pixel2x2_bot.sym} 3550 -10850 0 0 {name=x1449}
C {openDVS_pixel2x2_bot.sym} 3890 -10850 0 0 {name=x1450}
C {openDVS_pixel2x2_bot.sym} 4230 -10850 0 0 {name=x1451}
C {openDVS_pixel2x2_bot.sym} 4570 -10850 0 0 {name=x1452}
C {openDVS_pixel2x2_bot.sym} 4910 -10850 0 0 {name=x1453}
C {openDVS_pixel2x2_bot.sym} 5250 -10850 0 0 {name=x1454}
C {openDVS_pixel2x2_bot.sym} 5590 -10850 0 0 {name=x1455}
C {openDVS_pixel2x2_bot.sym} 5930 -10850 0 0 {name=x1456}
C {openDVS_pixel2x2_bot.sym} 6270 -10850 0 0 {name=x1457}
C {openDVS_pixel2x2_bot.sym} 6610 -10850 0 0 {name=x1458}
C {openDVS_pixel2x2_bot.sym} 6950 -10850 0 0 {name=x1459}
C {openDVS_pixel2x2_bot.sym} 7290 -10850 0 0 {name=x1460}
C {openDVS_pixel2x2_bot.sym} 7630 -10850 0 0 {name=x1461}
C {openDVS_pixel2x2_bot.sym} 7970 -10850 0 0 {name=x1462}
C {openDVS_pixel2x2_bot.sym} 8310 -10850 0 0 {name=x1463}
C {openDVS_pixel2x2_bot.sym} 8650 -10850 0 0 {name=x1464}
C {openDVS_pixel2x2_bot.sym} 8990 -10850 0 0 {name=x1465}
C {openDVS_pixel2x2_bot.sym} 9330 -10850 0 0 {name=x1466}
C {openDVS_pixel2x2_bot.sym} 9670 -10850 0 0 {name=x1467}
C {openDVS_pixel2x2_bot.sym} 10010 -10850 0 0 {name=x1468}
C {openDVS_pixel2x2_bot.sym} 10350 -10850 0 0 {name=x1469}
C {openDVS_pixel2x2_bot.sym} 10690 -10850 0 0 {name=x1470}
C {openDVS_pixel2x2_bot.sym} 11030 -10850 0 0 {name=x1471}
C {openDVS_pixel2x2_bot.sym} 490 -10330 0 0 {name=x1472}
C {openDVS_pixel2x2_bot.sym} 830 -10330 0 0 {name=x1473}
C {openDVS_pixel2x2_bot.sym} 1170 -10330 0 0 {name=x1474}
C {openDVS_pixel2x2_bot.sym} 1510 -10330 0 0 {name=x1475}
C {openDVS_pixel2x2_bot.sym} 1850 -10330 0 0 {name=x1476}
C {openDVS_pixel2x2_bot.sym} 2190 -10330 0 0 {name=x1477}
C {openDVS_pixel2x2_bot.sym} 2530 -10330 0 0 {name=x1478}
C {openDVS_pixel2x2_bot.sym} 2870 -10330 0 0 {name=x1479}
C {openDVS_pixel2x2_bot.sym} 3210 -10330 0 0 {name=x1480}
C {openDVS_pixel2x2_bot.sym} 3550 -10330 0 0 {name=x1481}
C {openDVS_pixel2x2_bot.sym} 3890 -10330 0 0 {name=x1482}
C {openDVS_pixel2x2_bot.sym} 4230 -10330 0 0 {name=x1483}
C {openDVS_pixel2x2_bot.sym} 4570 -10330 0 0 {name=x1484}
C {openDVS_pixel2x2_bot.sym} 4910 -10330 0 0 {name=x1485}
C {openDVS_pixel2x2_bot.sym} 5250 -10330 0 0 {name=x1486}
C {openDVS_pixel2x2_bot.sym} 5590 -10330 0 0 {name=x1487}
C {openDVS_pixel2x2_bot.sym} 5930 -10330 0 0 {name=x1488}
C {openDVS_pixel2x2_bot.sym} 6270 -10330 0 0 {name=x1489}
C {openDVS_pixel2x2_bot.sym} 6610 -10330 0 0 {name=x1490}
C {openDVS_pixel2x2_bot.sym} 6950 -10330 0 0 {name=x1491}
C {openDVS_pixel2x2_bot.sym} 7290 -10330 0 0 {name=x1492}
C {openDVS_pixel2x2_bot.sym} 7630 -10330 0 0 {name=x1493}
C {openDVS_pixel2x2_bot.sym} 7970 -10330 0 0 {name=x1494}
C {openDVS_pixel2x2_bot.sym} 8310 -10330 0 0 {name=x1495}
C {openDVS_pixel2x2_bot.sym} 8650 -10330 0 0 {name=x1496}
C {openDVS_pixel2x2_bot.sym} 8990 -10330 0 0 {name=x1497}
C {openDVS_pixel2x2_bot.sym} 9330 -10330 0 0 {name=x1498}
C {openDVS_pixel2x2_bot.sym} 9670 -10330 0 0 {name=x1499}
C {openDVS_pixel2x2_bot.sym} 10010 -10330 0 0 {name=x1500}
C {openDVS_pixel2x2_bot.sym} 10350 -10330 0 0 {name=x1501}
C {openDVS_pixel2x2_bot.sym} 10690 -10330 0 0 {name=x1502}
C {openDVS_pixel2x2_bot.sym} 11030 -10330 0 0 {name=x1503}
C {openDVS_pixel2x2_bot.sym} 490 -9810 0 0 {name=x1504}
C {openDVS_pixel2x2_bot.sym} 830 -9810 0 0 {name=x1505}
C {openDVS_pixel2x2_bot.sym} 1170 -9810 0 0 {name=x1506}
C {openDVS_pixel2x2_bot.sym} 1510 -9810 0 0 {name=x1507}
C {openDVS_pixel2x2_bot.sym} 1850 -9810 0 0 {name=x1508}
C {openDVS_pixel2x2_bot.sym} 2190 -9810 0 0 {name=x1509}
C {openDVS_pixel2x2_bot.sym} 2530 -9810 0 0 {name=x1510}
C {openDVS_pixel2x2_bot.sym} 2870 -9810 0 0 {name=x1511}
C {openDVS_pixel2x2_bot.sym} 3210 -9810 0 0 {name=x1512}
C {openDVS_pixel2x2_bot.sym} 3550 -9810 0 0 {name=x1513}
C {openDVS_pixel2x2_bot.sym} 3890 -9810 0 0 {name=x1514}
C {openDVS_pixel2x2_bot.sym} 4230 -9810 0 0 {name=x1515}
C {openDVS_pixel2x2_bot.sym} 4570 -9810 0 0 {name=x1516}
C {openDVS_pixel2x2_bot.sym} 4910 -9810 0 0 {name=x1517}
C {openDVS_pixel2x2_bot.sym} 5250 -9810 0 0 {name=x1518}
C {openDVS_pixel2x2_bot.sym} 5590 -9810 0 0 {name=x1519}
C {openDVS_pixel2x2_bot.sym} 5930 -9810 0 0 {name=x1520}
C {openDVS_pixel2x2_bot.sym} 6270 -9810 0 0 {name=x1521}
C {openDVS_pixel2x2_bot.sym} 6610 -9810 0 0 {name=x1522}
C {openDVS_pixel2x2_bot.sym} 6950 -9810 0 0 {name=x1523}
C {openDVS_pixel2x2_bot.sym} 7290 -9810 0 0 {name=x1524}
C {openDVS_pixel2x2_bot.sym} 7630 -9810 0 0 {name=x1525}
C {openDVS_pixel2x2_bot.sym} 7970 -9810 0 0 {name=x1526}
C {openDVS_pixel2x2_bot.sym} 8310 -9810 0 0 {name=x1527}
C {openDVS_pixel2x2_bot.sym} 8650 -9810 0 0 {name=x1528}
C {openDVS_pixel2x2_bot.sym} 8990 -9810 0 0 {name=x1529}
C {openDVS_pixel2x2_bot.sym} 9330 -9810 0 0 {name=x1530}
C {openDVS_pixel2x2_bot.sym} 9670 -9810 0 0 {name=x1531}
C {openDVS_pixel2x2_bot.sym} 10010 -9810 0 0 {name=x1532}
C {openDVS_pixel2x2_bot.sym} 10350 -9810 0 0 {name=x1533}
C {openDVS_pixel2x2_bot.sym} 10690 -9810 0 0 {name=x1534}
C {openDVS_pixel2x2_bot.sym} 11030 -9810 0 0 {name=x1535}
C {openDVS_pixel2x2_bot.sym} 490 -9290 0 0 {name=x1536}
C {openDVS_pixel2x2_bot.sym} 830 -9290 0 0 {name=x1537}
C {openDVS_pixel2x2_bot.sym} 1170 -9290 0 0 {name=x1538}
C {openDVS_pixel2x2_bot.sym} 1510 -9290 0 0 {name=x1539}
C {openDVS_pixel2x2_bot.sym} 1850 -9290 0 0 {name=x1540}
C {openDVS_pixel2x2_bot.sym} 2190 -9290 0 0 {name=x1541}
C {openDVS_pixel2x2_bot.sym} 2530 -9290 0 0 {name=x1542}
C {openDVS_pixel2x2_bot.sym} 2870 -9290 0 0 {name=x1543}
C {openDVS_pixel2x2_bot.sym} 3210 -9290 0 0 {name=x1544}
C {openDVS_pixel2x2_bot.sym} 3550 -9290 0 0 {name=x1545}
C {openDVS_pixel2x2_bot.sym} 3890 -9290 0 0 {name=x1546}
C {openDVS_pixel2x2_bot.sym} 4230 -9290 0 0 {name=x1547}
C {openDVS_pixel2x2_bot.sym} 4570 -9290 0 0 {name=x1548}
C {openDVS_pixel2x2_bot.sym} 4910 -9290 0 0 {name=x1549}
C {openDVS_pixel2x2_bot.sym} 5250 -9290 0 0 {name=x1550}
C {openDVS_pixel2x2_bot.sym} 5590 -9290 0 0 {name=x1551}
C {openDVS_pixel2x2_bot.sym} 5930 -9290 0 0 {name=x1552}
C {openDVS_pixel2x2_bot.sym} 6270 -9290 0 0 {name=x1553}
C {openDVS_pixel2x2_bot.sym} 6610 -9290 0 0 {name=x1554}
C {openDVS_pixel2x2_bot.sym} 6950 -9290 0 0 {name=x1555}
C {openDVS_pixel2x2_bot.sym} 7290 -9290 0 0 {name=x1556}
C {openDVS_pixel2x2_bot.sym} 7630 -9290 0 0 {name=x1557}
C {openDVS_pixel2x2_bot.sym} 7970 -9290 0 0 {name=x1558}
C {openDVS_pixel2x2_bot.sym} 8310 -9290 0 0 {name=x1559}
C {openDVS_pixel2x2_bot.sym} 8650 -9290 0 0 {name=x1560}
C {openDVS_pixel2x2_bot.sym} 8990 -9290 0 0 {name=x1561}
C {openDVS_pixel2x2_bot.sym} 9330 -9290 0 0 {name=x1562}
C {openDVS_pixel2x2_bot.sym} 9670 -9290 0 0 {name=x1563}
C {openDVS_pixel2x2_bot.sym} 10010 -9290 0 0 {name=x1564}
C {openDVS_pixel2x2_bot.sym} 10350 -9290 0 0 {name=x1565}
C {openDVS_pixel2x2_bot.sym} 10690 -9290 0 0 {name=x1566}
C {openDVS_pixel2x2_bot.sym} 11030 -9290 0 0 {name=x1567}
C {openDVS_pixel2x2_bot.sym} 490 -8770 0 0 {name=x1568}
C {openDVS_pixel2x2_bot.sym} 830 -8770 0 0 {name=x1569}
C {openDVS_pixel2x2_bot.sym} 1170 -8770 0 0 {name=x1570}
C {openDVS_pixel2x2_bot.sym} 1510 -8770 0 0 {name=x1571}
C {openDVS_pixel2x2_bot.sym} 1850 -8770 0 0 {name=x1572}
C {openDVS_pixel2x2_bot.sym} 2190 -8770 0 0 {name=x1573}
C {openDVS_pixel2x2_bot.sym} 2530 -8770 0 0 {name=x1574}
C {openDVS_pixel2x2_bot.sym} 2870 -8770 0 0 {name=x1575}
C {openDVS_pixel2x2_bot.sym} 3210 -8770 0 0 {name=x1576}
C {openDVS_pixel2x2_bot.sym} 3550 -8770 0 0 {name=x1577}
C {openDVS_pixel2x2_bot.sym} 3890 -8770 0 0 {name=x1578}
C {openDVS_pixel2x2_bot.sym} 4230 -8770 0 0 {name=x1579}
C {openDVS_pixel2x2_bot.sym} 4570 -8770 0 0 {name=x1580}
C {openDVS_pixel2x2_bot.sym} 4910 -8770 0 0 {name=x1581}
C {openDVS_pixel2x2_bot.sym} 5250 -8770 0 0 {name=x1582}
C {openDVS_pixel2x2_bot.sym} 5590 -8770 0 0 {name=x1583}
C {openDVS_pixel2x2_bot.sym} 5930 -8770 0 0 {name=x1584}
C {openDVS_pixel2x2_bot.sym} 6270 -8770 0 0 {name=x1585}
C {openDVS_pixel2x2_bot.sym} 6610 -8770 0 0 {name=x1586}
C {openDVS_pixel2x2_bot.sym} 6950 -8770 0 0 {name=x1587}
C {openDVS_pixel2x2_bot.sym} 7290 -8770 0 0 {name=x1588}
C {openDVS_pixel2x2_bot.sym} 7630 -8770 0 0 {name=x1589}
C {openDVS_pixel2x2_bot.sym} 7970 -8770 0 0 {name=x1590}
C {openDVS_pixel2x2_bot.sym} 8310 -8770 0 0 {name=x1591}
C {openDVS_pixel2x2_bot.sym} 8650 -8770 0 0 {name=x1592}
C {openDVS_pixel2x2_bot.sym} 8990 -8770 0 0 {name=x1593}
C {openDVS_pixel2x2_bot.sym} 9330 -8770 0 0 {name=x1594}
C {openDVS_pixel2x2_bot.sym} 9670 -8770 0 0 {name=x1595}
C {openDVS_pixel2x2_bot.sym} 10010 -8770 0 0 {name=x1596}
C {openDVS_pixel2x2_bot.sym} 10350 -8770 0 0 {name=x1597}
C {openDVS_pixel2x2_bot.sym} 10690 -8770 0 0 {name=x1598}
C {openDVS_pixel2x2_bot.sym} 11030 -8770 0 0 {name=x1599}
C {openDVS_pixel2x2_bot.sym} 490 -8250 0 0 {name=x1600}
C {openDVS_pixel2x2_bot.sym} 830 -8250 0 0 {name=x1601}
C {openDVS_pixel2x2_bot.sym} 1170 -8250 0 0 {name=x1602}
C {openDVS_pixel2x2_bot.sym} 1510 -8250 0 0 {name=x1603}
C {openDVS_pixel2x2_bot.sym} 1850 -8250 0 0 {name=x1604}
C {openDVS_pixel2x2_bot.sym} 2190 -8250 0 0 {name=x1605}
C {openDVS_pixel2x2_bot.sym} 2530 -8250 0 0 {name=x1606}
C {openDVS_pixel2x2_bot.sym} 2870 -8250 0 0 {name=x1607}
C {openDVS_pixel2x2_bot.sym} 3210 -8250 0 0 {name=x1608}
C {openDVS_pixel2x2_bot.sym} 3550 -8250 0 0 {name=x1609}
C {openDVS_pixel2x2_bot.sym} 3890 -8250 0 0 {name=x1610}
C {openDVS_pixel2x2_bot.sym} 4230 -8250 0 0 {name=x1611}
C {openDVS_pixel2x2_bot.sym} 4570 -8250 0 0 {name=x1612}
C {openDVS_pixel2x2_bot.sym} 4910 -8250 0 0 {name=x1613}
C {openDVS_pixel2x2_bot.sym} 5250 -8250 0 0 {name=x1614}
C {openDVS_pixel2x2_bot.sym} 5590 -8250 0 0 {name=x1615}
C {openDVS_pixel2x2_bot.sym} 5930 -8250 0 0 {name=x1616}
C {openDVS_pixel2x2_bot.sym} 6270 -8250 0 0 {name=x1617}
C {openDVS_pixel2x2_bot.sym} 6610 -8250 0 0 {name=x1618}
C {openDVS_pixel2x2_bot.sym} 6950 -8250 0 0 {name=x1619}
C {openDVS_pixel2x2_bot.sym} 7290 -8250 0 0 {name=x1620}
C {openDVS_pixel2x2_bot.sym} 7630 -8250 0 0 {name=x1621}
C {openDVS_pixel2x2_bot.sym} 7970 -8250 0 0 {name=x1622}
C {openDVS_pixel2x2_bot.sym} 8310 -8250 0 0 {name=x1623}
C {openDVS_pixel2x2_bot.sym} 8650 -8250 0 0 {name=x1624}
C {openDVS_pixel2x2_bot.sym} 8990 -8250 0 0 {name=x1625}
C {openDVS_pixel2x2_bot.sym} 9330 -8250 0 0 {name=x1626}
C {openDVS_pixel2x2_bot.sym} 9670 -8250 0 0 {name=x1627}
C {openDVS_pixel2x2_bot.sym} 10010 -8250 0 0 {name=x1628}
C {openDVS_pixel2x2_bot.sym} 10350 -8250 0 0 {name=x1629}
C {openDVS_pixel2x2_bot.sym} 10690 -8250 0 0 {name=x1630}
C {openDVS_pixel2x2_bot.sym} 11030 -8250 0 0 {name=x1631}
C {openDVS_pixel2x2_bot.sym} 490 -7730 0 0 {name=x1632}
C {openDVS_pixel2x2_bot.sym} 830 -7730 0 0 {name=x1633}
C {openDVS_pixel2x2_bot.sym} 1170 -7730 0 0 {name=x1634}
C {openDVS_pixel2x2_bot.sym} 1510 -7730 0 0 {name=x1635}
C {openDVS_pixel2x2_bot.sym} 1850 -7730 0 0 {name=x1636}
C {openDVS_pixel2x2_bot.sym} 2190 -7730 0 0 {name=x1637}
C {openDVS_pixel2x2_bot.sym} 2530 -7730 0 0 {name=x1638}
C {openDVS_pixel2x2_bot.sym} 2870 -7730 0 0 {name=x1639}
C {openDVS_pixel2x2_bot.sym} 3210 -7730 0 0 {name=x1640}
C {openDVS_pixel2x2_bot.sym} 3550 -7730 0 0 {name=x1641}
C {openDVS_pixel2x2_bot.sym} 3890 -7730 0 0 {name=x1642}
C {openDVS_pixel2x2_bot.sym} 4230 -7730 0 0 {name=x1643}
C {openDVS_pixel2x2_bot.sym} 4570 -7730 0 0 {name=x1644}
C {openDVS_pixel2x2_bot.sym} 4910 -7730 0 0 {name=x1645}
C {openDVS_pixel2x2_bot.sym} 5250 -7730 0 0 {name=x1646}
C {openDVS_pixel2x2_bot.sym} 5590 -7730 0 0 {name=x1647}
C {openDVS_pixel2x2_bot.sym} 5930 -7730 0 0 {name=x1648}
C {openDVS_pixel2x2_bot.sym} 6270 -7730 0 0 {name=x1649}
C {openDVS_pixel2x2_bot.sym} 6610 -7730 0 0 {name=x1650}
C {openDVS_pixel2x2_bot.sym} 6950 -7730 0 0 {name=x1651}
C {openDVS_pixel2x2_bot.sym} 7290 -7730 0 0 {name=x1652}
C {openDVS_pixel2x2_bot.sym} 7630 -7730 0 0 {name=x1653}
C {openDVS_pixel2x2_bot.sym} 7970 -7730 0 0 {name=x1654}
C {openDVS_pixel2x2_bot.sym} 8310 -7730 0 0 {name=x1655}
C {openDVS_pixel2x2_bot.sym} 8650 -7730 0 0 {name=x1656}
C {openDVS_pixel2x2_bot.sym} 8990 -7730 0 0 {name=x1657}
C {openDVS_pixel2x2_bot.sym} 9330 -7730 0 0 {name=x1658}
C {openDVS_pixel2x2_bot.sym} 9670 -7730 0 0 {name=x1659}
C {openDVS_pixel2x2_bot.sym} 10010 -7730 0 0 {name=x1660}
C {openDVS_pixel2x2_bot.sym} 10350 -7730 0 0 {name=x1661}
C {openDVS_pixel2x2_bot.sym} 10690 -7730 0 0 {name=x1662}
C {openDVS_pixel2x2_bot.sym} 11030 -7730 0 0 {name=x1663}
C {openDVS_pixel2x2_bot.sym} 490 -7210 0 0 {name=x1664}
C {openDVS_pixel2x2_bot.sym} 830 -7210 0 0 {name=x1665}
C {openDVS_pixel2x2_bot.sym} 1170 -7210 0 0 {name=x1666}
C {openDVS_pixel2x2_bot.sym} 1510 -7210 0 0 {name=x1667}
C {openDVS_pixel2x2_bot.sym} 1850 -7210 0 0 {name=x1668}
C {openDVS_pixel2x2_bot.sym} 2190 -7210 0 0 {name=x1669}
C {openDVS_pixel2x2_bot.sym} 2530 -7210 0 0 {name=x1670}
C {openDVS_pixel2x2_bot.sym} 2870 -7210 0 0 {name=x1671}
C {openDVS_pixel2x2_bot.sym} 3210 -7210 0 0 {name=x1672}
C {openDVS_pixel2x2_bot.sym} 3550 -7210 0 0 {name=x1673}
C {openDVS_pixel2x2_bot.sym} 3890 -7210 0 0 {name=x1674}
C {openDVS_pixel2x2_bot.sym} 4230 -7210 0 0 {name=x1675}
C {openDVS_pixel2x2_bot.sym} 4570 -7210 0 0 {name=x1676}
C {openDVS_pixel2x2_bot.sym} 4910 -7210 0 0 {name=x1677}
C {openDVS_pixel2x2_bot.sym} 5250 -7210 0 0 {name=x1678}
C {openDVS_pixel2x2_bot.sym} 5590 -7210 0 0 {name=x1679}
C {openDVS_pixel2x2_bot.sym} 5930 -7210 0 0 {name=x1680}
C {openDVS_pixel2x2_bot.sym} 6270 -7210 0 0 {name=x1681}
C {openDVS_pixel2x2_bot.sym} 6610 -7210 0 0 {name=x1682}
C {openDVS_pixel2x2_bot.sym} 6950 -7210 0 0 {name=x1683}
C {openDVS_pixel2x2_bot.sym} 7290 -7210 0 0 {name=x1684}
C {openDVS_pixel2x2_bot.sym} 7630 -7210 0 0 {name=x1685}
C {openDVS_pixel2x2_bot.sym} 7970 -7210 0 0 {name=x1686}
C {openDVS_pixel2x2_bot.sym} 8310 -7210 0 0 {name=x1687}
C {openDVS_pixel2x2_bot.sym} 8650 -7210 0 0 {name=x1688}
C {openDVS_pixel2x2_bot.sym} 8990 -7210 0 0 {name=x1689}
C {openDVS_pixel2x2_bot.sym} 9330 -7210 0 0 {name=x1690}
C {openDVS_pixel2x2_bot.sym} 9670 -7210 0 0 {name=x1691}
C {openDVS_pixel2x2_bot.sym} 10010 -7210 0 0 {name=x1692}
C {openDVS_pixel2x2_bot.sym} 10350 -7210 0 0 {name=x1693}
C {openDVS_pixel2x2_bot.sym} 10690 -7210 0 0 {name=x1694}
C {openDVS_pixel2x2_bot.sym} 11030 -7210 0 0 {name=x1695}
C {openDVS_pixel2x2_bot.sym} 490 -6690 0 0 {name=x1696}
C {openDVS_pixel2x2_bot.sym} 830 -6690 0 0 {name=x1697}
C {openDVS_pixel2x2_bot.sym} 1170 -6690 0 0 {name=x1698}
C {openDVS_pixel2x2_bot.sym} 1510 -6690 0 0 {name=x1699}
C {openDVS_pixel2x2_bot.sym} 1850 -6690 0 0 {name=x1700}
C {openDVS_pixel2x2_bot.sym} 2190 -6690 0 0 {name=x1701}
C {openDVS_pixel2x2_bot.sym} 2530 -6690 0 0 {name=x1702}
C {openDVS_pixel2x2_bot.sym} 2870 -6690 0 0 {name=x1703}
C {openDVS_pixel2x2_bot.sym} 3210 -6690 0 0 {name=x1704}
C {openDVS_pixel2x2_bot.sym} 3550 -6690 0 0 {name=x1705}
C {openDVS_pixel2x2_bot.sym} 3890 -6690 0 0 {name=x1706}
C {openDVS_pixel2x2_bot.sym} 4230 -6690 0 0 {name=x1707}
C {openDVS_pixel2x2_bot.sym} 4570 -6690 0 0 {name=x1708}
C {openDVS_pixel2x2_bot.sym} 4910 -6690 0 0 {name=x1709}
C {openDVS_pixel2x2_bot.sym} 5250 -6690 0 0 {name=x1710}
C {openDVS_pixel2x2_bot.sym} 5590 -6690 0 0 {name=x1711}
C {openDVS_pixel2x2_bot.sym} 5930 -6690 0 0 {name=x1712}
C {openDVS_pixel2x2_bot.sym} 6270 -6690 0 0 {name=x1713}
C {openDVS_pixel2x2_bot.sym} 6610 -6690 0 0 {name=x1714}
C {openDVS_pixel2x2_bot.sym} 6950 -6690 0 0 {name=x1715}
C {openDVS_pixel2x2_bot.sym} 7290 -6690 0 0 {name=x1716}
C {openDVS_pixel2x2_bot.sym} 7630 -6690 0 0 {name=x1717}
C {openDVS_pixel2x2_bot.sym} 7970 -6690 0 0 {name=x1718}
C {openDVS_pixel2x2_bot.sym} 8310 -6690 0 0 {name=x1719}
C {openDVS_pixel2x2_bot.sym} 8650 -6690 0 0 {name=x1720}
C {openDVS_pixel2x2_bot.sym} 8990 -6690 0 0 {name=x1721}
C {openDVS_pixel2x2_bot.sym} 9330 -6690 0 0 {name=x1722}
C {openDVS_pixel2x2_bot.sym} 9670 -6690 0 0 {name=x1723}
C {openDVS_pixel2x2_bot.sym} 10010 -6690 0 0 {name=x1724}
C {openDVS_pixel2x2_bot.sym} 10350 -6690 0 0 {name=x1725}
C {openDVS_pixel2x2_bot.sym} 10690 -6690 0 0 {name=x1726}
C {openDVS_pixel2x2_bot.sym} 11030 -6690 0 0 {name=x1727}
C {openDVS_pixel2x2_bot.sym} 490 -6170 0 0 {name=x1728}
C {openDVS_pixel2x2_bot.sym} 830 -6170 0 0 {name=x1729}
C {openDVS_pixel2x2_bot.sym} 1170 -6170 0 0 {name=x1730}
C {openDVS_pixel2x2_bot.sym} 1510 -6170 0 0 {name=x1731}
C {openDVS_pixel2x2_bot.sym} 1850 -6170 0 0 {name=x1732}
C {openDVS_pixel2x2_bot.sym} 2190 -6170 0 0 {name=x1733}
C {openDVS_pixel2x2_bot.sym} 2530 -6170 0 0 {name=x1734}
C {openDVS_pixel2x2_bot.sym} 2870 -6170 0 0 {name=x1735}
C {openDVS_pixel2x2_bot.sym} 3210 -6170 0 0 {name=x1736}
C {openDVS_pixel2x2_bot.sym} 3550 -6170 0 0 {name=x1737}
C {openDVS_pixel2x2_bot.sym} 3890 -6170 0 0 {name=x1738}
C {openDVS_pixel2x2_bot.sym} 4230 -6170 0 0 {name=x1739}
C {openDVS_pixel2x2_bot.sym} 4570 -6170 0 0 {name=x1740}
C {openDVS_pixel2x2_bot.sym} 4910 -6170 0 0 {name=x1741}
C {openDVS_pixel2x2_bot.sym} 5250 -6170 0 0 {name=x1742}
C {openDVS_pixel2x2_bot.sym} 5590 -6170 0 0 {name=x1743}
C {openDVS_pixel2x2_bot.sym} 5930 -6170 0 0 {name=x1744}
C {openDVS_pixel2x2_bot.sym} 6270 -6170 0 0 {name=x1745}
C {openDVS_pixel2x2_bot.sym} 6610 -6170 0 0 {name=x1746}
C {openDVS_pixel2x2_bot.sym} 6950 -6170 0 0 {name=x1747}
C {openDVS_pixel2x2_bot.sym} 7290 -6170 0 0 {name=x1748}
C {openDVS_pixel2x2_bot.sym} 7630 -6170 0 0 {name=x1749}
C {openDVS_pixel2x2_bot.sym} 7970 -6170 0 0 {name=x1750}
C {openDVS_pixel2x2_bot.sym} 8310 -6170 0 0 {name=x1751}
C {openDVS_pixel2x2_bot.sym} 8650 -6170 0 0 {name=x1752}
C {openDVS_pixel2x2_bot.sym} 8990 -6170 0 0 {name=x1753}
C {openDVS_pixel2x2_bot.sym} 9330 -6170 0 0 {name=x1754}
C {openDVS_pixel2x2_bot.sym} 9670 -6170 0 0 {name=x1755}
C {openDVS_pixel2x2_bot.sym} 10010 -6170 0 0 {name=x1756}
C {openDVS_pixel2x2_bot.sym} 10350 -6170 0 0 {name=x1757}
C {openDVS_pixel2x2_bot.sym} 10690 -6170 0 0 {name=x1758}
C {openDVS_pixel2x2_bot.sym} 11030 -6170 0 0 {name=x1759}
C {openDVS_pixel2x2_bot.sym} 490 -5650 0 0 {name=x1760}
C {openDVS_pixel2x2_bot.sym} 830 -5650 0 0 {name=x1761}
C {openDVS_pixel2x2_bot.sym} 1170 -5650 0 0 {name=x1762}
C {openDVS_pixel2x2_bot.sym} 1510 -5650 0 0 {name=x1763}
C {openDVS_pixel2x2_bot.sym} 1850 -5650 0 0 {name=x1764}
C {openDVS_pixel2x2_bot.sym} 2190 -5650 0 0 {name=x1765}
C {openDVS_pixel2x2_bot.sym} 2530 -5650 0 0 {name=x1766}
C {openDVS_pixel2x2_bot.sym} 2870 -5650 0 0 {name=x1767}
C {openDVS_pixel2x2_bot.sym} 3210 -5650 0 0 {name=x1768}
C {openDVS_pixel2x2_bot.sym} 3550 -5650 0 0 {name=x1769}
C {openDVS_pixel2x2_bot.sym} 3890 -5650 0 0 {name=x1770}
C {openDVS_pixel2x2_bot.sym} 4230 -5650 0 0 {name=x1771}
C {openDVS_pixel2x2_bot.sym} 4570 -5650 0 0 {name=x1772}
C {openDVS_pixel2x2_bot.sym} 4910 -5650 0 0 {name=x1773}
C {openDVS_pixel2x2_bot.sym} 5250 -5650 0 0 {name=x1774}
C {openDVS_pixel2x2_bot.sym} 5590 -5650 0 0 {name=x1775}
C {openDVS_pixel2x2_bot.sym} 5930 -5650 0 0 {name=x1776}
C {openDVS_pixel2x2_bot.sym} 6270 -5650 0 0 {name=x1777}
C {openDVS_pixel2x2_bot.sym} 6610 -5650 0 0 {name=x1778}
C {openDVS_pixel2x2_bot.sym} 6950 -5650 0 0 {name=x1779}
C {openDVS_pixel2x2_bot.sym} 7290 -5650 0 0 {name=x1780}
C {openDVS_pixel2x2_bot.sym} 7630 -5650 0 0 {name=x1781}
C {openDVS_pixel2x2_bot.sym} 7970 -5650 0 0 {name=x1782}
C {openDVS_pixel2x2_bot.sym} 8310 -5650 0 0 {name=x1783}
C {openDVS_pixel2x2_bot.sym} 8650 -5650 0 0 {name=x1784}
C {openDVS_pixel2x2_bot.sym} 8990 -5650 0 0 {name=x1785}
C {openDVS_pixel2x2_bot.sym} 9330 -5650 0 0 {name=x1786}
C {openDVS_pixel2x2_bot.sym} 9670 -5650 0 0 {name=x1787}
C {openDVS_pixel2x2_bot.sym} 10010 -5650 0 0 {name=x1788}
C {openDVS_pixel2x2_bot.sym} 10350 -5650 0 0 {name=x1789}
C {openDVS_pixel2x2_bot.sym} 10690 -5650 0 0 {name=x1790}
C {openDVS_pixel2x2_bot.sym} 11030 -5650 0 0 {name=x1791}
C {openDVS_pixel2x2_bot.sym} 490 -5130 0 0 {name=x1792}
C {openDVS_pixel2x2_bot.sym} 830 -5130 0 0 {name=x1793}
C {openDVS_pixel2x2_bot.sym} 1170 -5130 0 0 {name=x1794}
C {openDVS_pixel2x2_bot.sym} 1510 -5130 0 0 {name=x1795}
C {openDVS_pixel2x2_bot.sym} 1850 -5130 0 0 {name=x1796}
C {openDVS_pixel2x2_bot.sym} 2190 -5130 0 0 {name=x1797}
C {openDVS_pixel2x2_bot.sym} 2530 -5130 0 0 {name=x1798}
C {openDVS_pixel2x2_bot.sym} 2870 -5130 0 0 {name=x1799}
C {openDVS_pixel2x2_bot.sym} 3210 -5130 0 0 {name=x1800}
C {openDVS_pixel2x2_bot.sym} 3550 -5130 0 0 {name=x1801}
C {openDVS_pixel2x2_bot.sym} 3890 -5130 0 0 {name=x1802}
C {openDVS_pixel2x2_bot.sym} 4230 -5130 0 0 {name=x1803}
C {openDVS_pixel2x2_bot.sym} 4570 -5130 0 0 {name=x1804}
C {openDVS_pixel2x2_bot.sym} 4910 -5130 0 0 {name=x1805}
C {openDVS_pixel2x2_bot.sym} 5250 -5130 0 0 {name=x1806}
C {openDVS_pixel2x2_bot.sym} 5590 -5130 0 0 {name=x1807}
C {openDVS_pixel2x2_bot.sym} 5930 -5130 0 0 {name=x1808}
C {openDVS_pixel2x2_bot.sym} 6270 -5130 0 0 {name=x1809}
C {openDVS_pixel2x2_bot.sym} 6610 -5130 0 0 {name=x1810}
C {openDVS_pixel2x2_bot.sym} 6950 -5130 0 0 {name=x1811}
C {openDVS_pixel2x2_bot.sym} 7290 -5130 0 0 {name=x1812}
C {openDVS_pixel2x2_bot.sym} 7630 -5130 0 0 {name=x1813}
C {openDVS_pixel2x2_bot.sym} 7970 -5130 0 0 {name=x1814}
C {openDVS_pixel2x2_bot.sym} 8310 -5130 0 0 {name=x1815}
C {openDVS_pixel2x2_bot.sym} 8650 -5130 0 0 {name=x1816}
C {openDVS_pixel2x2_bot.sym} 8990 -5130 0 0 {name=x1817}
C {openDVS_pixel2x2_bot.sym} 9330 -5130 0 0 {name=x1818}
C {openDVS_pixel2x2_bot.sym} 9670 -5130 0 0 {name=x1819}
C {openDVS_pixel2x2_bot.sym} 10010 -5130 0 0 {name=x1820}
C {openDVS_pixel2x2_bot.sym} 10350 -5130 0 0 {name=x1821}
C {openDVS_pixel2x2_bot.sym} 10690 -5130 0 0 {name=x1822}
C {openDVS_pixel2x2_bot.sym} 11030 -5130 0 0 {name=x1823}
C {openDVS_pixel2x2_bot.sym} 490 -4610 0 0 {name=x1824}
C {openDVS_pixel2x2_bot.sym} 830 -4610 0 0 {name=x1825}
C {openDVS_pixel2x2_bot.sym} 1170 -4610 0 0 {name=x1826}
C {openDVS_pixel2x2_bot.sym} 1510 -4610 0 0 {name=x1827}
C {openDVS_pixel2x2_bot.sym} 1850 -4610 0 0 {name=x1828}
C {openDVS_pixel2x2_bot.sym} 2190 -4610 0 0 {name=x1829}
C {openDVS_pixel2x2_bot.sym} 2530 -4610 0 0 {name=x1830}
C {openDVS_pixel2x2_bot.sym} 2870 -4610 0 0 {name=x1831}
C {openDVS_pixel2x2_bot.sym} 3210 -4610 0 0 {name=x1832}
C {openDVS_pixel2x2_bot.sym} 3550 -4610 0 0 {name=x1833}
C {openDVS_pixel2x2_bot.sym} 3890 -4610 0 0 {name=x1834}
C {openDVS_pixel2x2_bot.sym} 4230 -4610 0 0 {name=x1835}
C {openDVS_pixel2x2_bot.sym} 4570 -4610 0 0 {name=x1836}
C {openDVS_pixel2x2_bot.sym} 4910 -4610 0 0 {name=x1837}
C {openDVS_pixel2x2_bot.sym} 5250 -4610 0 0 {name=x1838}
C {openDVS_pixel2x2_bot.sym} 5590 -4610 0 0 {name=x1839}
C {openDVS_pixel2x2_bot.sym} 5930 -4610 0 0 {name=x1840}
C {openDVS_pixel2x2_bot.sym} 6270 -4610 0 0 {name=x1841}
C {openDVS_pixel2x2_bot.sym} 6610 -4610 0 0 {name=x1842}
C {openDVS_pixel2x2_bot.sym} 6950 -4610 0 0 {name=x1843}
C {openDVS_pixel2x2_bot.sym} 7290 -4610 0 0 {name=x1844}
C {openDVS_pixel2x2_bot.sym} 7630 -4610 0 0 {name=x1845}
C {openDVS_pixel2x2_bot.sym} 7970 -4610 0 0 {name=x1846}
C {openDVS_pixel2x2_bot.sym} 8310 -4610 0 0 {name=x1847}
C {openDVS_pixel2x2_bot.sym} 8650 -4610 0 0 {name=x1848}
C {openDVS_pixel2x2_bot.sym} 8990 -4610 0 0 {name=x1849}
C {openDVS_pixel2x2_bot.sym} 9330 -4610 0 0 {name=x1850}
C {openDVS_pixel2x2_bot.sym} 9670 -4610 0 0 {name=x1851}
C {openDVS_pixel2x2_bot.sym} 10010 -4610 0 0 {name=x1852}
C {openDVS_pixel2x2_bot.sym} 10350 -4610 0 0 {name=x1853}
C {openDVS_pixel2x2_bot.sym} 10690 -4610 0 0 {name=x1854}
C {openDVS_pixel2x2_bot.sym} 11030 -4610 0 0 {name=x1855}
C {openDVS_pixel2x2_bot.sym} 490 -4090 0 0 {name=x1856}
C {openDVS_pixel2x2_bot.sym} 830 -4090 0 0 {name=x1857}
C {openDVS_pixel2x2_bot.sym} 1170 -4090 0 0 {name=x1858}
C {openDVS_pixel2x2_bot.sym} 1510 -4090 0 0 {name=x1859}
C {openDVS_pixel2x2_bot.sym} 1850 -4090 0 0 {name=x1860}
C {openDVS_pixel2x2_bot.sym} 2190 -4090 0 0 {name=x1861}
C {openDVS_pixel2x2_bot.sym} 2530 -4090 0 0 {name=x1862}
C {openDVS_pixel2x2_bot.sym} 2870 -4090 0 0 {name=x1863}
C {openDVS_pixel2x2_bot.sym} 3210 -4090 0 0 {name=x1864}
C {openDVS_pixel2x2_bot.sym} 3550 -4090 0 0 {name=x1865}
C {openDVS_pixel2x2_bot.sym} 3890 -4090 0 0 {name=x1866}
C {openDVS_pixel2x2_bot.sym} 4230 -4090 0 0 {name=x1867}
C {openDVS_pixel2x2_bot.sym} 4570 -4090 0 0 {name=x1868}
C {openDVS_pixel2x2_bot.sym} 4910 -4090 0 0 {name=x1869}
C {openDVS_pixel2x2_bot.sym} 5250 -4090 0 0 {name=x1870}
C {openDVS_pixel2x2_bot.sym} 5590 -4090 0 0 {name=x1871}
C {openDVS_pixel2x2_bot.sym} 5930 -4090 0 0 {name=x1872}
C {openDVS_pixel2x2_bot.sym} 6270 -4090 0 0 {name=x1873}
C {openDVS_pixel2x2_bot.sym} 6610 -4090 0 0 {name=x1874}
C {openDVS_pixel2x2_bot.sym} 6950 -4090 0 0 {name=x1875}
C {openDVS_pixel2x2_bot.sym} 7290 -4090 0 0 {name=x1876}
C {openDVS_pixel2x2_bot.sym} 7630 -4090 0 0 {name=x1877}
C {openDVS_pixel2x2_bot.sym} 7970 -4090 0 0 {name=x1878}
C {openDVS_pixel2x2_bot.sym} 8310 -4090 0 0 {name=x1879}
C {openDVS_pixel2x2_bot.sym} 8650 -4090 0 0 {name=x1880}
C {openDVS_pixel2x2_bot.sym} 8990 -4090 0 0 {name=x1881}
C {openDVS_pixel2x2_bot.sym} 9330 -4090 0 0 {name=x1882}
C {openDVS_pixel2x2_bot.sym} 9670 -4090 0 0 {name=x1883}
C {openDVS_pixel2x2_bot.sym} 10010 -4090 0 0 {name=x1884}
C {openDVS_pixel2x2_bot.sym} 10350 -4090 0 0 {name=x1885}
C {openDVS_pixel2x2_bot.sym} 10690 -4090 0 0 {name=x1886}
C {openDVS_pixel2x2_bot.sym} 11030 -4090 0 0 {name=x1887}
C {openDVS_pixel2x2_bot.sym} 490 -3570 0 0 {name=x1888}
C {openDVS_pixel2x2_bot.sym} 830 -3570 0 0 {name=x1889}
C {openDVS_pixel2x2_bot.sym} 1170 -3570 0 0 {name=x1890}
C {openDVS_pixel2x2_bot.sym} 1510 -3570 0 0 {name=x1891}
C {openDVS_pixel2x2_bot.sym} 1850 -3570 0 0 {name=x1892}
C {openDVS_pixel2x2_bot.sym} 2190 -3570 0 0 {name=x1893}
C {openDVS_pixel2x2_bot.sym} 2530 -3570 0 0 {name=x1894}
C {openDVS_pixel2x2_bot.sym} 2870 -3570 0 0 {name=x1895}
C {openDVS_pixel2x2_bot.sym} 3210 -3570 0 0 {name=x1896}
C {openDVS_pixel2x2_bot.sym} 3550 -3570 0 0 {name=x1897}
C {openDVS_pixel2x2_bot.sym} 3890 -3570 0 0 {name=x1898}
C {openDVS_pixel2x2_bot.sym} 4230 -3570 0 0 {name=x1899}
C {openDVS_pixel2x2_bot.sym} 4570 -3570 0 0 {name=x1900}
C {openDVS_pixel2x2_bot.sym} 4910 -3570 0 0 {name=x1901}
C {openDVS_pixel2x2_bot.sym} 5250 -3570 0 0 {name=x1902}
C {openDVS_pixel2x2_bot.sym} 5590 -3570 0 0 {name=x1903}
C {openDVS_pixel2x2_bot.sym} 5930 -3570 0 0 {name=x1904}
C {openDVS_pixel2x2_bot.sym} 6270 -3570 0 0 {name=x1905}
C {openDVS_pixel2x2_bot.sym} 6610 -3570 0 0 {name=x1906}
C {openDVS_pixel2x2_bot.sym} 6950 -3570 0 0 {name=x1907}
C {openDVS_pixel2x2_bot.sym} 7290 -3570 0 0 {name=x1908}
C {openDVS_pixel2x2_bot.sym} 7630 -3570 0 0 {name=x1909}
C {openDVS_pixel2x2_bot.sym} 7970 -3570 0 0 {name=x1910}
C {openDVS_pixel2x2_bot.sym} 8310 -3570 0 0 {name=x1911}
C {openDVS_pixel2x2_bot.sym} 8650 -3570 0 0 {name=x1912}
C {openDVS_pixel2x2_bot.sym} 8990 -3570 0 0 {name=x1913}
C {openDVS_pixel2x2_bot.sym} 9330 -3570 0 0 {name=x1914}
C {openDVS_pixel2x2_bot.sym} 9670 -3570 0 0 {name=x1915}
C {openDVS_pixel2x2_bot.sym} 10010 -3570 0 0 {name=x1916}
C {openDVS_pixel2x2_bot.sym} 10350 -3570 0 0 {name=x1917}
C {openDVS_pixel2x2_bot.sym} 10690 -3570 0 0 {name=x1918}
C {openDVS_pixel2x2_bot.sym} 11030 -3570 0 0 {name=x1919}
C {openDVS_pixel2x2_bot.sym} 490 -3050 0 0 {name=x1920}
C {openDVS_pixel2x2_bot.sym} 830 -3050 0 0 {name=x1921}
C {openDVS_pixel2x2_bot.sym} 1170 -3050 0 0 {name=x1922}
C {openDVS_pixel2x2_bot.sym} 1510 -3050 0 0 {name=x1923}
C {openDVS_pixel2x2_bot.sym} 1850 -3050 0 0 {name=x1924}
C {openDVS_pixel2x2_bot.sym} 2190 -3050 0 0 {name=x1925}
C {openDVS_pixel2x2_bot.sym} 2530 -3050 0 0 {name=x1926}
C {openDVS_pixel2x2_bot.sym} 2870 -3050 0 0 {name=x1927}
C {openDVS_pixel2x2_bot.sym} 3210 -3050 0 0 {name=x1928}
C {openDVS_pixel2x2_bot.sym} 3550 -3050 0 0 {name=x1929}
C {openDVS_pixel2x2_bot.sym} 3890 -3050 0 0 {name=x1930}
C {openDVS_pixel2x2_bot.sym} 4230 -3050 0 0 {name=x1931}
C {openDVS_pixel2x2_bot.sym} 4570 -3050 0 0 {name=x1932}
C {openDVS_pixel2x2_bot.sym} 4910 -3050 0 0 {name=x1933}
C {openDVS_pixel2x2_bot.sym} 5250 -3050 0 0 {name=x1934}
C {openDVS_pixel2x2_bot.sym} 5590 -3050 0 0 {name=x1935}
C {openDVS_pixel2x2_bot.sym} 5930 -3050 0 0 {name=x1936}
C {openDVS_pixel2x2_bot.sym} 6270 -3050 0 0 {name=x1937}
C {openDVS_pixel2x2_bot.sym} 6610 -3050 0 0 {name=x1938}
C {openDVS_pixel2x2_bot.sym} 6950 -3050 0 0 {name=x1939}
C {openDVS_pixel2x2_bot.sym} 7290 -3050 0 0 {name=x1940}
C {openDVS_pixel2x2_bot.sym} 7630 -3050 0 0 {name=x1941}
C {openDVS_pixel2x2_bot.sym} 7970 -3050 0 0 {name=x1942}
C {openDVS_pixel2x2_bot.sym} 8310 -3050 0 0 {name=x1943}
C {openDVS_pixel2x2_bot.sym} 8650 -3050 0 0 {name=x1944}
C {openDVS_pixel2x2_bot.sym} 8990 -3050 0 0 {name=x1945}
C {openDVS_pixel2x2_bot.sym} 9330 -3050 0 0 {name=x1946}
C {openDVS_pixel2x2_bot.sym} 9670 -3050 0 0 {name=x1947}
C {openDVS_pixel2x2_bot.sym} 10010 -3050 0 0 {name=x1948}
C {openDVS_pixel2x2_bot.sym} 10350 -3050 0 0 {name=x1949}
C {openDVS_pixel2x2_bot.sym} 10690 -3050 0 0 {name=x1950}
C {openDVS_pixel2x2_bot.sym} 11030 -3050 0 0 {name=x1951}
C {openDVS_pixel2x2_bot.sym} 490 -2530 0 0 {name=x1952}
C {openDVS_pixel2x2_bot.sym} 830 -2530 0 0 {name=x1953}
C {openDVS_pixel2x2_bot.sym} 1170 -2530 0 0 {name=x1954}
C {openDVS_pixel2x2_bot.sym} 1510 -2530 0 0 {name=x1955}
C {openDVS_pixel2x2_bot.sym} 1850 -2530 0 0 {name=x1956}
C {openDVS_pixel2x2_bot.sym} 2190 -2530 0 0 {name=x1957}
C {openDVS_pixel2x2_bot.sym} 2530 -2530 0 0 {name=x1958}
C {openDVS_pixel2x2_bot.sym} 2870 -2530 0 0 {name=x1959}
C {openDVS_pixel2x2_bot.sym} 3210 -2530 0 0 {name=x1960}
C {openDVS_pixel2x2_bot.sym} 3550 -2530 0 0 {name=x1961}
C {openDVS_pixel2x2_bot.sym} 3890 -2530 0 0 {name=x1962}
C {openDVS_pixel2x2_bot.sym} 4230 -2530 0 0 {name=x1963}
C {openDVS_pixel2x2_bot.sym} 4570 -2530 0 0 {name=x1964}
C {openDVS_pixel2x2_bot.sym} 4910 -2530 0 0 {name=x1965}
C {openDVS_pixel2x2_bot.sym} 5250 -2530 0 0 {name=x1966}
C {openDVS_pixel2x2_bot.sym} 5590 -2530 0 0 {name=x1967}
C {openDVS_pixel2x2_bot.sym} 5930 -2530 0 0 {name=x1968}
C {openDVS_pixel2x2_bot.sym} 6270 -2530 0 0 {name=x1969}
C {openDVS_pixel2x2_bot.sym} 6610 -2530 0 0 {name=x1970}
C {openDVS_pixel2x2_bot.sym} 6950 -2530 0 0 {name=x1971}
C {openDVS_pixel2x2_bot.sym} 7290 -2530 0 0 {name=x1972}
C {openDVS_pixel2x2_bot.sym} 7630 -2530 0 0 {name=x1973}
C {openDVS_pixel2x2_bot.sym} 7970 -2530 0 0 {name=x1974}
C {openDVS_pixel2x2_bot.sym} 8310 -2530 0 0 {name=x1975}
C {openDVS_pixel2x2_bot.sym} 8650 -2530 0 0 {name=x1976}
C {openDVS_pixel2x2_bot.sym} 8990 -2530 0 0 {name=x1977}
C {openDVS_pixel2x2_bot.sym} 9330 -2530 0 0 {name=x1978}
C {openDVS_pixel2x2_bot.sym} 9670 -2530 0 0 {name=x1979}
C {openDVS_pixel2x2_bot.sym} 10010 -2530 0 0 {name=x1980}
C {openDVS_pixel2x2_bot.sym} 10350 -2530 0 0 {name=x1981}
C {openDVS_pixel2x2_bot.sym} 10690 -2530 0 0 {name=x1982}
C {openDVS_pixel2x2_bot.sym} 11030 -2530 0 0 {name=x1983}
C {openDVS_pixel2x2_bot.sym} 490 -2010 0 0 {name=x1984}
C {openDVS_pixel2x2_bot.sym} 830 -2010 0 0 {name=x1985}
C {openDVS_pixel2x2_bot.sym} 1170 -2010 0 0 {name=x1986}
C {openDVS_pixel2x2_bot.sym} 1510 -2010 0 0 {name=x1987}
C {openDVS_pixel2x2_bot.sym} 1850 -2010 0 0 {name=x1988}
C {openDVS_pixel2x2_bot.sym} 2190 -2010 0 0 {name=x1989}
C {openDVS_pixel2x2_bot.sym} 2530 -2010 0 0 {name=x1990}
C {openDVS_pixel2x2_bot.sym} 2870 -2010 0 0 {name=x1991}
C {openDVS_pixel2x2_bot.sym} 3210 -2010 0 0 {name=x1992}
C {openDVS_pixel2x2_bot.sym} 3550 -2010 0 0 {name=x1993}
C {openDVS_pixel2x2_bot.sym} 3890 -2010 0 0 {name=x1994}
C {openDVS_pixel2x2_bot.sym} 4230 -2010 0 0 {name=x1995}
C {openDVS_pixel2x2_bot.sym} 4570 -2010 0 0 {name=x1996}
C {openDVS_pixel2x2_bot.sym} 4910 -2010 0 0 {name=x1997}
C {openDVS_pixel2x2_bot.sym} 5250 -2010 0 0 {name=x1998}
C {openDVS_pixel2x2_bot.sym} 5590 -2010 0 0 {name=x1999}
C {openDVS_pixel2x2_bot.sym} 5930 -2010 0 0 {name=x2000}
C {openDVS_pixel2x2_bot.sym} 6270 -2010 0 0 {name=x2001}
C {openDVS_pixel2x2_bot.sym} 6610 -2010 0 0 {name=x2002}
C {openDVS_pixel2x2_bot.sym} 6950 -2010 0 0 {name=x2003}
C {openDVS_pixel2x2_bot.sym} 7290 -2010 0 0 {name=x2004}
C {openDVS_pixel2x2_bot.sym} 7630 -2010 0 0 {name=x2005}
C {openDVS_pixel2x2_bot.sym} 7970 -2010 0 0 {name=x2006}
C {openDVS_pixel2x2_bot.sym} 8310 -2010 0 0 {name=x2007}
C {openDVS_pixel2x2_bot.sym} 8650 -2010 0 0 {name=x2008}
C {openDVS_pixel2x2_bot.sym} 8990 -2010 0 0 {name=x2009}
C {openDVS_pixel2x2_bot.sym} 9330 -2010 0 0 {name=x2010}
C {openDVS_pixel2x2_bot.sym} 9670 -2010 0 0 {name=x2011}
C {openDVS_pixel2x2_bot.sym} 10010 -2010 0 0 {name=x2012}
C {openDVS_pixel2x2_bot.sym} 10350 -2010 0 0 {name=x2013}
C {openDVS_pixel2x2_bot.sym} 10690 -2010 0 0 {name=x2014}
C {openDVS_pixel2x2_bot.sym} 11030 -2010 0 0 {name=x2015}
C {openDVS_pixel2x2_bot.sym} 490 -1490 0 0 {name=x2016}
C {openDVS_pixel2x2_bot.sym} 830 -1490 0 0 {name=x2017}
C {openDVS_pixel2x2_bot.sym} 1170 -1490 0 0 {name=x2018}
C {openDVS_pixel2x2_bot.sym} 1510 -1490 0 0 {name=x2019}
C {openDVS_pixel2x2_bot.sym} 1850 -1490 0 0 {name=x2020}
C {openDVS_pixel2x2_bot.sym} 2190 -1490 0 0 {name=x2021}
C {openDVS_pixel2x2_bot.sym} 2530 -1490 0 0 {name=x2022}
C {openDVS_pixel2x2_bot.sym} 2870 -1490 0 0 {name=x2023}
C {openDVS_pixel2x2_bot.sym} 3210 -1490 0 0 {name=x2024}
C {openDVS_pixel2x2_bot.sym} 3550 -1490 0 0 {name=x2025}
C {openDVS_pixel2x2_bot.sym} 3890 -1490 0 0 {name=x2026}
C {openDVS_pixel2x2_bot.sym} 4230 -1490 0 0 {name=x2027}
C {openDVS_pixel2x2_bot.sym} 4570 -1490 0 0 {name=x2028}
C {openDVS_pixel2x2_bot.sym} 4910 -1490 0 0 {name=x2029}
C {openDVS_pixel2x2_bot.sym} 5250 -1490 0 0 {name=x2030}
C {openDVS_pixel2x2_bot.sym} 5590 -1490 0 0 {name=x2031}
C {openDVS_pixel2x2_bot.sym} 5930 -1490 0 0 {name=x2032}
C {openDVS_pixel2x2_bot.sym} 6270 -1490 0 0 {name=x2033}
C {openDVS_pixel2x2_bot.sym} 6610 -1490 0 0 {name=x2034}
C {openDVS_pixel2x2_bot.sym} 6950 -1490 0 0 {name=x2035}
C {openDVS_pixel2x2_bot.sym} 7290 -1490 0 0 {name=x2036}
C {openDVS_pixel2x2_bot.sym} 7630 -1490 0 0 {name=x2037}
C {openDVS_pixel2x2_bot.sym} 7970 -1490 0 0 {name=x2038}
C {openDVS_pixel2x2_bot.sym} 8310 -1490 0 0 {name=x2039}
C {openDVS_pixel2x2_bot.sym} 8650 -1490 0 0 {name=x2040}
C {openDVS_pixel2x2_bot.sym} 8990 -1490 0 0 {name=x2041}
C {openDVS_pixel2x2_bot.sym} 9330 -1490 0 0 {name=x2042}
C {openDVS_pixel2x2_bot.sym} 9670 -1490 0 0 {name=x2043}
C {openDVS_pixel2x2_bot.sym} 10010 -1490 0 0 {name=x2044}
C {openDVS_pixel2x2_bot.sym} 10350 -1490 0 0 {name=x2045}
C {openDVS_pixel2x2_bot.sym} 10690 -1490 0 0 {name=x2046}
C {openDVS_pixel2x2_bot.sym} 11030 -1490 0 0 {name=x2047}
C {openDVS_pixel2x2_bot.sym} 490 -970 0 0 {name=x2048}
C {openDVS_pixel2x2_bot.sym} 830 -970 0 0 {name=x2049}
C {openDVS_pixel2x2_bot.sym} 1170 -970 0 0 {name=x2050}
C {openDVS_pixel2x2_bot.sym} 1510 -970 0 0 {name=x2051}
C {openDVS_pixel2x2_bot.sym} 1850 -970 0 0 {name=x2052}
C {openDVS_pixel2x2_bot.sym} 2190 -970 0 0 {name=x2053}
C {openDVS_pixel2x2_bot.sym} 2530 -970 0 0 {name=x2054}
C {openDVS_pixel2x2_bot.sym} 2870 -970 0 0 {name=x2055}
C {openDVS_pixel2x2_bot.sym} 3210 -970 0 0 {name=x2056}
C {openDVS_pixel2x2_bot.sym} 3550 -970 0 0 {name=x2057}
C {openDVS_pixel2x2_bot.sym} 3890 -970 0 0 {name=x2058}
C {openDVS_pixel2x2_bot.sym} 4230 -970 0 0 {name=x2059}
C {openDVS_pixel2x2_bot.sym} 4570 -970 0 0 {name=x2060}
C {openDVS_pixel2x2_bot.sym} 4910 -970 0 0 {name=x2061}
C {openDVS_pixel2x2_bot.sym} 5250 -970 0 0 {name=x2062}
C {openDVS_pixel2x2_bot.sym} 5590 -970 0 0 {name=x2063}
C {openDVS_pixel2x2_bot.sym} 5930 -970 0 0 {name=x2064}
C {openDVS_pixel2x2_bot.sym} 6270 -970 0 0 {name=x2065}
C {openDVS_pixel2x2_bot.sym} 6610 -970 0 0 {name=x2066}
C {openDVS_pixel2x2_bot.sym} 6950 -970 0 0 {name=x2067}
C {openDVS_pixel2x2_bot.sym} 7290 -970 0 0 {name=x2068}
C {openDVS_pixel2x2_bot.sym} 7630 -970 0 0 {name=x2069}
C {openDVS_pixel2x2_bot.sym} 7970 -970 0 0 {name=x2070}
C {openDVS_pixel2x2_bot.sym} 8310 -970 0 0 {name=x2071}
C {openDVS_pixel2x2_bot.sym} 8650 -970 0 0 {name=x2072}
C {openDVS_pixel2x2_bot.sym} 8990 -970 0 0 {name=x2073}
C {openDVS_pixel2x2_bot.sym} 9330 -970 0 0 {name=x2074}
C {openDVS_pixel2x2_bot.sym} 9670 -970 0 0 {name=x2075}
C {openDVS_pixel2x2_bot.sym} 10010 -970 0 0 {name=x2076}
C {openDVS_pixel2x2_bot.sym} 10350 -970 0 0 {name=x2077}
C {openDVS_pixel2x2_bot.sym} 10690 -970 0 0 {name=x2078}
C {openDVS_pixel2x2_bot.sym} 11030 -970 0 0 {name=x2079}
