v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
C {openDVS_pixel2x2.sym} 0 0 0 0 {name=x0}
