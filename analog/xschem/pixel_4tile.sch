v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
C {pixel_layout_tile.sym} 130 -140 0 0 {name=x1}
C {pixel_layout_tile.sym} 430 -140 0 0 {name=x2}
