** sch_path: analog/cace/templates/tb_PixelGain_ac_mc.sch
**.subckt tb_PixelGain_ac_mc
Vgnd gnd GND! 0
Vvdd vdd GND! {xvdd}
Iipd vpd gnd dc {xipd} ac {xipd}
CloadPD1 vpd gnd 'xCloadPD' m=1
Vmeas_ipd1 vpd_in vpd 0
XMDiffBn DiffBn DiffBn gnd gnd sky130_fd_pr__nfet_01v8 L=2 W=1 nf=1 ad='int((1 + 1)/2) * 1 / 1 * 0.29'
+ as='int((1 + 2)/2) * 1 / 1 * 0.29' pd='2*int((1 + 1)/2) * (1 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (1 / 1 + 0.29)'
+ nrd='0.29 / 1 ' nrs='0.29 / 1 ' sa=0 sb=0 sd=0 mult=1 m=1
IDiffBn vdd DiffBn {xDiffBn}
IPrBp PrBp gnd {xPrBp}
XMPrBp PrBp PrBp vdd vdd sky130_fd_pr__pfet_01v8_hvt L=0.15 W=1 nf=1 ad='int((1 + 1)/2) * 1 / 1 * 0.29'
+ as='int((1 + 2)/2) * 1 / 1 * 0.29' pd='2*int((1 + 1)/2) * (1 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (1 / 1 + 0.29)'
+ nrd='0.29 / 1 ' nrs='0.29 / 1 ' sa=0 sb=0 sd=0 mult=1 m=1
IPrSFBp PrSFBp gnd {xPrSFBp}
XMPrSFBp PrSFBp PrSFBp vdd vdd sky130_fd_pr__pfet_01v8 L=4 W=1 nf=2 ad='int((2 + 1)/2) * 1 / 2 * 0.29'
+ as='int((2 + 2)/2) * 1 / 2 * 0.29' pd='2*int((2 + 1)/2) * (1 / 2 + 0.29)' ps='2*int((2 + 2)/2) * (1 / 2 + 0.29)'
+ nrd='0.29 / 1 ' nrs='0.29 / 1 ' sa=0 sb=0 sd=0 mult=1 m=1
**** begin user architecture code

** opencircuitdesign pdks install
.lib $::SKYWATER_MODELS/sky130.lib.spice CACE{corner}
.include CACE{DUT_path}
.include CACE{root}/netlist/schematic/PixelPhotoreceptor.spice
.include CACE{root}/netlist/schematic/PixelSourceFollower.spice
.include CACE{root}/netlist/schematic/PixelChangeAmplifier.spice

** Manual instantiation (symbols not available in CACE run directory)
xpr vdd PrBp gnd vpd_in vpr PixelPhotoreceptor
xsf vdd PrSFBp gnd vpr vsf PixelSourceFollower
xchamp vdd DiffBn gnd vsf vdiff nRst PixelChangeAmplifier



.temp CACE{temperature}

.option SEED=CACE[CACE{seed=12345} + CACE{iterations=0}]
.option gmin=1e-16 abstol=1e-15 vntol=1e-9 reltol=1e-4 chgtol=1e-16
.option itl1=500 itl2=200
.option gminsteps=200 srcsteps=200

.param xvdd = CACE{vdd}
.param xipd = CACE{xipd}
.param xPrBp = CACE{xPrBp}
.param xPrSFBp = CACE{xPrSFBp}
.param xDiffBn = CACE{xDiffBn}
.param xCloadPD = CACE{xCloadPD}

** nRst at vdd for normal operation (Mrst OFF)
VnRst nRst gnd {xvdd}

** Large inductor: DC short (sets OP) but AC open (no effect on freq response)
** Provides DC path for floating cap node xchamp.vd through vdiff
Lbias vdiff xchamp.vd 1000T

.save all

.control
** OP with nRst=vdd, inductor provides DC path for floating nodes
op
let vd_op = v(xchamp.vd)
let vdiff_op = v(vdiff)
echo
echo '=== OP (nRst=vdd) ==='
echo '    vd    =' $&vd_op 'V'
echo '    vdiff =' $&vdiff_op 'V'

** AC sweep from this operating point
ac dec 50 1m 1G
write CACE{filename}_CACE{N}.raw

echo
echo '=== AC analysis complete, running post-processing ==='
shell python3 CACE{root}/cace/scripts/tb_PixelGain_ac.py CACE{simpath} CACE{filename} CACE{N}
.endc


**** end user architecture code
**.ends
.GLOBAL GND!
.end
