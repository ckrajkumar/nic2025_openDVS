** sch_path: analog/cace/templates/tb_PixelComparators_dc_2x2.sch
**.subckt tb_PixelComparators_dc_2x2
XMOnBn OnBn OnBn gnd gnd sky130_fd_pr__nfet_01v8 L=1.5 W=1.5 nf=1 ad='int((1 + 1)/2) * 1.5 / 1 * 0.29'
+ as='int((1 + 2)/2) * 1.5 / 1 * 0.29' pd='2*int((1 + 1)/2) * (1.5 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (1.5 / 1 + 0.29)'
+ nrd='0.29 / 1.5 ' nrs='0.29 / 1.5 ' sa=0 sb=0 sd=0 mult=1 m=1
IOnBn vdd OnBn {xOnBn}
XMOffBn OffBn OffBn gnd gnd sky130_fd_pr__nfet_01v8 L=1.5 W=1.5 nf=1 ad='int((1 + 1)/2) * 1.5 / 1 * 0.29'
+ as='int((1 + 2)/2) * 1.5 / 1 * 0.29' pd='2*int((1 + 1)/2) * (1.5 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (1.5 / 1 + 0.29)'
+ nrd='0.29 / 1.5 ' nrs='0.29 / 1.5 ' sa=0 sb=0 sd=0 mult=1 m=1
IOffBn vdd OffBn {xOffBn}
Vgnd1 gnd GND! 0
Vvdd1 vdd GND! {xvdd}
xpix2x2 gnd gnd gnd gnd gnd gnd gnd gnd vpd3 vpd2 vpd1 vpd0 vdd gnd gnd OnBn OffBn gnd vdd gnd gnd
+ openDVS_pixel2x2
I0 vpd1 gnd 'xipd1'
I1 vpd2 gnd 'xipd2'
I2 vpd3 gnd 'xipd3'
I3 vpd0 gnd 'xipd0'
**** begin user architecture code

** opencircuitdesign pdks install
.lib $::SKYWATER_MODELS/sky130.lib.spice CACE{corner}



.include CACE{root}/xschem/openDVS_pixel2x2_pex_CACE{xPexType}.spice

.temp CACE{temperature}

.option gmin=1e-16 abstol=1e-15 vntol=1e-9 reltol=1e-4 chgtol=1e-16
.option itl1=500 itl2=200
.option gminsteps=200 srcsteps=200

.param xvdd = CACE{vdd}
** Bias set: 1 = OnBn=200nA / OffBn=0.5nA, 2 = OnBn=100nA / OffBn=1nA
.param xBiasSet = CACE{xBiasSet}
.param xOnBn = '(xBiasSet < 1.5) ? 200e-9 : 100e-9'
.param xOffBn = '(xBiasSet < 1.5) ? 0.5e-9 : 1e-9'

.param xipd0 = CACE{xipd0}
.param xipd1 = CACE{xipd1}
.param xipd2 = CACE{xipd2}
.param xipd3 = CACE{xipd3}

** Force vdiff on Pix[0] — must be in SPICE code, not as schematic wire
** (xschem mangles dots in net labels during netlisting)
Vvdiff_pex xpix2x2.Pix[0].vdiff gnd {xvdiff}

** Bsource probes: mirror bracket-containing internal nodes to top-level names
Bprobe_on on_mon 0 V = v(xpix2x2.pix[0].on)
Bprobe_noff noff_mon 0 V = v(xpix2x2.pix[0].noff)

.param xvdiff = 0

.save all

.control
dc vvdiff_pex 0 CACE{vdd} 0.1m
write CACE{filename}_CACE{N}.raw

shell python3 CACE{root}/cace/scripts/tb_PixelComparators_dc_2x2.py CACE{simpath} CACE{filename} CACE{N}
.endc


**** end user architecture code
**.ends
.GLOBAL GND!
.end
