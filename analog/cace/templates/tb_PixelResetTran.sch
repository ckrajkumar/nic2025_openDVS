** sch_path: analog/cace/templates/tb_PixelResetTran.sch
**.subckt tb_PixelResetTran
Vgnd gnd GND! 0
Vvdd vdd GND! {xvdd}
xChAmp vdd DiffBn gnd gnd vdiff nRst PixelChangeAmplifier
XMDiffBn DiffBn DiffBn gnd gnd sky130_fd_pr__nfet_01v8 L=2 W=1 nf=1 ad='int((1 + 1)/2) * 1 / 1 * 0.29'
+ as='int((1 + 2)/2) * 1 / 1 * 0.29' pd='2*int((1 + 1)/2) * (1 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (1 / 1 + 0.29)'
+ nrd='0.29 / 1 ' nrs='0.29 / 1 ' sa=0 sb=0 sd=0 mult=1 m=1
IDiffBn vdd DiffBn {xDiffBn}
* noconn vdiff
IRefrBp RefrBp gnd {xRefrBp}
XMRefrBp RefrBp RefrBp vdd vdd sky130_fd_pr__pfet_01v8 L=8 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29'
+ as='int((1 + 2)/2) * 2 / 1 * 0.29' pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)'
+ nrd='0.29 / 2 ' nrs='0.29 / 2 ' sa=0 sb=0 sd=0 mult=1 m=1
XMOnBn OnBn OnBn gnd gnd sky130_fd_pr__nfet_01v8 L=2 W=1 nf=1 ad='int((1 + 1)/2) * 1 / 1 * 0.29' as='int((1 + 2)/2) * 1 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (1 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (1 / 1 + 0.29)' nrd='0.29 / 1 ' nrs='0.29 / 1 '
+ sa=0 sb=0 sd=0 mult=1 m=1
IOnBn vdd OnBn {xOnBn}
XMOffBn OffBn OffBn gnd gnd sky130_fd_pr__nfet_01v8 L=2 W=1 nf=1 ad='int((1 + 1)/2) * 1 / 1 * 0.29' as='int((1 + 2)/2) * 1 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (1 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (1 / 1 + 0.29)' nrd='0.29 / 1 ' nrs='0.29 / 1 '
+ sa=0 sb=0 sd=0 mult=1 m=1
IOffBn vdd OffBn {xOffBn}
VpixRst pixRst gnd {xvdd}
**** begin user architecture code

** opencircuitdesign pdks install
.lib $::SKYWATER_MODELS/sky130.lib.spice CACE{corner}



.include CACE{DUT_path}
.include CACE{root}/netlist/schematic/PixelComparators.spice
.include CACE{root}/netlist/schematic/PixelResetGen.spice

** Manual instantiation (syms not found in CACE run dir)
xcomp vdd OnBn gnd vdiff ON OffBn nOFF PixelComparators
xrst pixRst gnd pixRst nRst RefrBp vdd PixelResetGen

.temp CACE{temperature}

.option gmin=1e-16 abstol=1e-15 vntol=1e-9 reltol=1e-4 chgtol=1e-16
.option method=gear maxord=2 trtol=1
.option itl1=500 itl2=200 itl4=50
.option gminsteps=200 srcsteps=200

.param xvdd = CACE{vdd}
.param xRefrBp = CACE{xRefrBp}
.param xDiffBn = CACE{xDiffBn}
.param xOnBn = CACE{xOnBn}
.param xOffBn = CACE{xOffBn}
.param xvsf = CACE{xvsf}

.save all
.save @m.xchamp.xmrst.msky130_fd_pr__pfet_01v8_hvt[id]
.save @m.xchamp.xmrst.msky130_fd_pr__pfet_01v8_hvt[ibd]
.save @m.xchamp.xmrst.msky130_fd_pr__pfet_01v8_hvt[ibs]
.save @m.xchamp.xmrst.msky130_fd_pr__pfet_01v8_hvt[igidl]
.save @m.xchamp.xmrst.msky130_fd_pr__pfet_01v8_hvt[igisl]

.control
** Phase 1: initial reset (VpixRst = xvdd from schematic)
stop when time > 1m
tran 100u 51 uic
let vdd_val = v(vdd)[length(v(vdd))-1]

** Phase 2: release reset with 10ns edge, run until ON fires or 45s timeout
let t1 = time[length(time)-1]
let t_ramp_end = t1 + 10n
alter @vpixrst[pwl] = [ $&t1 $&vdd_val $&t_ramp_end 0 ]
delete all
let on_thresh = 0.9 * vdd_val
stop when v(on) > $&on_thresh
stop when time > 45
resume

let t_on_event = time[length(time)-1]

** Phase 3: trigger second reset for 10us with 10ns edge (always, even without ON event)
let t3 = time[length(time)-1]
let t3_ramp = t3 + 10n
alter @vpixrst[pwl] = [ $&t3 0 $&t3_ramp $&vdd_val ]
delete all
let t_rst2_end = t3 + 10u
stop when time > $&t_rst2_end
resume

** Phase 4: release second reset with 10ns edge, run settling time
let t4 = time[length(time)-1]
let t4_ramp = t4 + 10n
alter @vpixrst[pwl] = [ $&t4 $&vdd_val $&t4_ramp 0 ]
delete all
let t_final = t_on_event + 0.5
if t_final > 50.9
  let t_final = 50.9
end
stop when time > $&t_final
resume

write CACE{filename}_CACE{N}.raw
shell python3 CACE{root}/cace/scripts/tb_PixelResetTran.py CACE{simpath} CACE{filename} CACE{N}
.endc


**** end user architecture code
**.ends

* expanding   symbol:  PixelChangeAmplifier.sym # of pins=6
** sym_path: analog/xschem/PixelChangeAmplifier.sym
** sch_path: analog/xschem/PixelChangeAmplifier.sch
.subckt PixelChangeAmplifier vdd DiffBn gnd vsf vdiff nRst
*.iopin DiffBn
*.iopin vsf
*.iopin vdd
*.iopin gnd
*.iopin vdiff
*.iopin nRst
XC1 vsf vd sky130_fd_pr__cap_mim_m3_1 W=1 L=1 MF=40 m=40
XC2 vd vdiff sky130_fd_pr__cap_mim_m3_1 W=1 L=1 MF=2 m=2
XMchAmpBias vdiff DiffBn gnd gnd sky130_fd_pr__nfet_01v8 L=2 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29'
+ as='int((1 + 2)/2) * 2 / 1 * 0.29' pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)'
+ nrd='0.29 / 2 ' nrs='0.29 / 2 ' sa=0 sb=0 sd=0 mult=1 m=1
XMrst vdiff nRst vd vdd sky130_fd_pr__pfet_01v8_hvt L=0.3 W=1 nf=1 ad='int((1 + 1)/2) * 1 / 1 * 0.29'
+ as='int((1 + 2)/2) * 1 / 1 * 0.29' pd='2*int((1 + 1)/2) * (1 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (1 / 1 + 0.29)'
+ nrd='0.29 / 1 ' nrs='0.29 / 1 ' sa=0 sb=0 sd=0 mult=1 m=1
XMchAmp vdiff vd vdd vdd sky130_fd_pr__pfet_01v8_hvt L=2 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29'
+ as='int((1 + 2)/2) * 2 / 1 * 0.29' pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)'
+ nrd='0.29 / 2 ' nrs='0.29 / 2 ' sa=0 sb=0 sd=0 mult=1 m=1
.ends

.GLOBAL GND!
.end
