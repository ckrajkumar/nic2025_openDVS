** sch_path: analog/cace/templates/tb_PixelResetTran_2x2.sch
**.subckt tb_PixelResetTran_2x2
IRefrBp RefrBp gnd {xRefrBp}
XMRefrBp RefrBp RefrBp vdd vdd sky130_fd_pr__pfet_01v8 L=1.5 W=0.42 nf=1 ad='int((1 + 1)/2) * 0.42 / 1 * 0.29'
+ as='int((1 + 2)/2) * 0.42 / 1 * 0.29' pd='2*int((1 + 1)/2) * (0.42 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (0.42 / 1 + 0.29)'
+ nrd='0.29 / 0.42 ' nrs='0.29 / 0.42 ' sa=0 sb=0 sd=0 mult=1 m=1
XMOnBn OnBn OnBn gnd gnd sky130_fd_pr__nfet_01v8 L=1.5 W=1.5 nf=1 ad='int((1 + 1)/2) * 1.5 / 1 * 0.29'
+ as='int((1 + 2)/2) * 1.5 / 1 * 0.29' pd='2*int((1 + 1)/2) * (1.5 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (1.5 / 1 + 0.29)'
+ nrd='0.29 / 1.5 ' nrs='0.29 / 1.5 ' sa=0 sb=0 sd=0 mult=1 m=1
IOnBn vdd OnBn {xOnBn}
XMOffBn OffBn OffBn gnd gnd sky130_fd_pr__nfet_01v8 L=1.5 W=1.5 nf=1 ad='int((1 + 1)/2) * 1.5 / 1 * 0.29'
+ as='int((1 + 2)/2) * 1.5 / 1 * 0.29' pd='2*int((1 + 1)/2) * (1.5 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (1.5 / 1 + 0.29)'
+ nrd='0.29 / 1.5 ' nrs='0.29 / 1.5 ' sa=0 sb=0 sd=0 mult=1 m=1
IOffBn vdd OffBn {xOffBn}
VpixRst pixRst gnd {xvdd}
xpix2x2 gnd pixRst gnd pixRst gnd gnd gnd gnd vpd3 vpd2 vpd1 vpd0 vdd gnd gnd OnBn OffBn DiffBn
+ PrSFBp RefrBp PrBp openDVS_pixel2x2
I0 vpd1 gnd 'xipd1'
I1 vpd2 gnd 'xipd2'
I2 vpd3 gnd 'xipd3'
I3 vpd0 gnd 'xipd0'
XMPrBp PrBp PrBp vdd vdd sky130_fd_pr__pfet_01v8 L=0.15 W=0.5 nf=1 ad='int((1 + 1)/2) * 0.5 / 1 * 0.29'
+ as='int((1 + 2)/2) * 0.5 / 1 * 0.29' pd='2*int((1 + 1)/2) * (0.5 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (0.5 / 1 + 0.29)'
+ nrd='0.29 / 0.5 ' nrs='0.29 / 0.5 ' sa=0 sb=0 sd=0 mult=1 m=1
IPrBp PrBp gnd {xPrBp}
XMPrSFBp PrSFBp PrSFBp vdd vdd sky130_fd_pr__pfet_01v8 L=1.5 W=0.42 nf=1 ad='int((1 + 1)/2) * 0.42 / 1 * 0.29'
+ as='int((1 + 2)/2) * 0.42 / 1 * 0.29' pd='2*int((1 + 1)/2) * (0.42 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (0.42 / 1 + 0.29)'
+ nrd='0.29 / 0.42 ' nrs='0.29 / 0.42 ' sa=0 sb=0 sd=0 mult=1 m=1
IPrSFBp PrSFBp gnd {xPrSFBp}
XMDiffBn DiffBn DiffBn gnd gnd sky130_fd_pr__nfet_01v8 L=1.5 W=1.5 nf=1 ad='int((1 + 1)/2) * 1.5 / 1 * 0.29'
+ as='int((1 + 2)/2) * 1.5 / 1 * 0.29' pd='2*int((1 + 1)/2) * (1.5 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (1.5 / 1 + 0.29)'
+ nrd='0.29 / 1.5 ' nrs='0.29 / 1.5 ' sa=0 sb=0 sd=0 mult=1 m=1
IDiffBn vdd DiffBn {xDiffBn}
Vgnd gnd GND! 0
Vvdd vdd GND! {xvdd}
**** begin user architecture code

** opencircuitdesign pdks install
.lib $::SKYWATER_MODELS/sky130.lib.spice CACE{corner}



.include CACE{root}/xschem/openDVS_pixel2x2_pex_CACE{xPexType}.spice

.temp CACE{temperature}

.option gmin=1e-17 abstol=1e-15 vntol=1e-9 reltol=1e-4 chgtol=1e-16
.option method=gear maxord=2 trtol=1
.option itl1=500 itl2=200 itl4=50
.option gminsteps=200 srcsteps=200
.option ramptime=100n

.param xvdd = CACE{vdd}
.param xPrBp = CACE{xPrBp}
.param xPrSFBp = CACE{xPrSFBp}
.param xDiffBn = CACE{xDiffBn}
.param xRefrBp = CACE{xRefrBp}
.param xOnBn = CACE{xOnBn}
.param xOffBn = CACE{xOffBn}

.param xipd0 = CACE{xipd0}
.param xipd1 = CACE{xipd1}
.param xipd2 = CACE{xipd2}
.param xipd3 = CACE{xipd3}

.save all

** Bsource probes: mirror bracket-containing internal nodes to top-level names
Bprobe_on on_mon 0 V = v(xpix2x2.pix[0].on)
Bprobe_nrst nrst_mon 0 V = v(xpix2x2.pix[0].nrst)
Bprobe_vdiff vdiff_mon 0 V = v(xpix2x2.pix[0].vdiff)

.control
** Phase 1: initial reset (VpixRst = xvdd, DC source)
stop when time > 1m
tran 100u 51 uic
let vdd_val = v(vdd)[length(v(vdd))-1]
echo
echo '=== Phase 1: initial reset complete (t=1ms) ==='

** Phase 2: release reset, run until ON fires
alter vpixrst = 0
delete all
let on_thresh = 0.9 * vdd_val
stop when v(on_mon) > $&on_thresh
stop when time > 45
resume

let t_on_event = time[length(time)-1]
echo
echo '=== Phase 2: ON event detected ==='
print t_on_event

** Phase 3: trigger second reset for 1ms
alter vpixrst = $&vdd_val
delete all
let t3 = time[length(time)-1]
let t_rst2_end = t3 + 1m
stop when time > $&t_rst2_end
resume

** Phase 4: release second reset, run settling time
alter vpixrst = 0
delete all
let t_final = t_on_event + 0.5
if t_final > 50.9
  let t_final = 50.9
end
stop when time > $&t_final
resume

write CACE{filename}_CACE{N}.raw
shell python3 CACE{root}/cace/scripts/tb_PixelResetTran_2x2.py CACE{simpath} CACE{filename} CACE{N}
.endc


**** end user architecture code
**.ends
.GLOBAL GND!
.end
