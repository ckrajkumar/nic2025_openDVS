** sch_path: analog/cace/templates/tb_PixelComparators_dc_mc.sch
**.subckt tb_PixelComparators_dc_mc
Vgnd gnd GND! 0
Vvdd vdd GND! {xvdd}
XMOnBn OnBn OnBn gnd gnd sky130_fd_pr__nfet_01v8 L=2 W=1 nf=1 ad='int((1 + 1)/2) * 1 / 1 * 0.29' as='int((1 + 2)/2) * 1 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (1 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (1 / 1 + 0.29)' nrd='0.29 / 1 ' nrs='0.29 / 1 '
+ sa=0 sb=0 sd=0 mult=1 m=1
IOnBn vdd OnBn {xOnBn}
XMOffBn OffBn OffBn gnd gnd sky130_fd_pr__nfet_01v8 L=2 W=1 nf=1 ad='int((1 + 1)/2) * 1 / 1 * 0.29' as='int((1 + 2)/2) * 1 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (1 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (1 / 1 + 0.29)' nrd='0.29 / 1 ' nrs='0.29 / 1 '
+ sa=0 sb=0 sd=0 mult=1 m=1
IOffBn vdd OffBn {xOffBn}
Vvdiff vdiff gnd 0
**** begin user architecture code

** opencircuitdesign pdks install
.lib $::SKYWATER_MODELS/sky130.lib.spice CACE{corner}
.include CACE{DUT_path}

** Manual instantiation (DUT symbol available, but explicit for clarity)
xcomp vdd OnBn gnd vdiff ON OffBn nOFF PixelComparators



.temp CACE{temperature}

.option SEED=CACE[CACE{seed=12345} + CACE{iterations=0}]
.option gmin=1e-16 abstol=1e-15 vntol=1e-9 reltol=1e-4 chgtol=1e-16
.option itl1=500 itl2=200
.option gminsteps=200 srcsteps=200

.param xvdd = CACE{vdd}
** Bias set: 1 = OnBn=200nA / OffBn=0.5nA, 2 = OnBn=100nA / OffBn=1nA
.param xBiasSet = CACE{xBiasSet}
.param xOnBn = '(xBiasSet < 1.5) ? 200e-9 : 100e-9'
.param xOffBn = '(xBiasSet < 1.5) ? 0.5e-9 : 1e-9'

.save all

.control
dc vvdiff 0 CACE{vdd} 0.1m
write CACE{filename}_CACE{N}.raw

shell python3 CACE{root}/cace/scripts/tb_PixelComparators_dc_mc.py CACE{simpath} CACE{filename} CACE{N}
.endc


**** end user architecture code
**.ends
.GLOBAL GND!
.end
