** sch_path: analog/cace/templates/tb_PixelComparators_dc.sch
**.subckt tb_PixelComparators_dc
Vgnd gnd GND! 0
Vvdd vdd GND! {xvdd}
XMOnBn OnBn OnBn gnd gnd sky130_fd_pr__nfet_01v8 L=2 W=1 nf=1 ad='int((1 + 1)/2) * 1 / 1 * 0.29' as='int((1 + 2)/2) * 1 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (1 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (1 / 1 + 0.29)' nrd='0.29 / 1 ' nrs='0.29 / 1 '
+ sa=0 sb=0 sd=0 mult=1 m=1
IOnBn vdd OnBn {xOnBn}
XMOffBn OffBn OffBn gnd gnd sky130_fd_pr__nfet_01v8 L=2 W=1 nf=1 ad='int((1 + 1)/2) * 1 / 1 * 0.29' as='int((1 + 2)/2) * 1 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (1 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (1 / 1 + 0.29)' nrd='0.29 / 1 ' nrs='0.29 / 1 '
+ sa=0 sb=0 sd=0 mult=1 m=1
IOffBn vdd OffBn {xOffBn}
Vvdiff vdiff gnd 0
**** begin user architecture code

** opencircuitdesign pdks install
.lib $::SKYWATER_MODELS/sky130.lib.spice CACE{corner}
.include CACE{DUT_path}

** Manual instantiation (DUT symbol available, but explicit for clarity)
xcomp vdd OnBn gnd vdiff ON OffBn nOFF PixelComparators



.temp CACE{temperature}

.option gmin=1e-16 abstol=1e-15 vntol=1e-9 reltol=1e-4 chgtol=1e-16
.option itl1=500 itl2=200
.option gminsteps=200 srcsteps=200

.param xvdd = CACE{vdd}
.param xOnBn = CACE{xOnBn}
.param xOffBn = CACE{xOffBn}

.save all

.control
dc vvdiff 0 CACE{vdd} 0.1m
write CACE{filename}_CACE{N}.raw

shell python3 CACE{root}/cace/scripts/tb_PixelComparators_dc.py CACE{simpath} CACE{filename} CACE{N}
.endc


**** end user architecture code
**.ends
.GLOBAL GND!
.end
