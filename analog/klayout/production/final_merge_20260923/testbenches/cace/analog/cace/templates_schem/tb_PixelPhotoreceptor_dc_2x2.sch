** sch_path: analog/klayout/production/final_merge_20260923/testbenches/cace/analog/cace/templates_schem/tb_PixelPhotoreceptor_dc_2x2.sch
**.subckt tb_PixelPhotoreceptor_dc_2x2
IPrBp PrBp gnd {xPrBp}
XMPrBp PrBp PrBp vdd vdd sky130_fd_pr__pfet_01v8 L=0.15 W=0.5 nf=1 ad='int((1 + 1)/2) * 0.5 / 1 * 0.29'
+ as='int((1 + 2)/2) * 0.5 / 1 * 0.29' pd='2*int((1 + 1)/2) * (0.5 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (0.5 / 1 + 0.29)'
+ nrd='0.29 / 0.5 ' nrs='0.29 / 0.5 ' sa=0 sb=0 sd=0 mult=1 m=1
IPrSFBp PrSFBp gnd {xPrSFBp}
XMPrSFBp PrSFBp PrSFBp vdd vdd sky130_fd_pr__pfet_01v8 L=1.5 W=0.42 nf=1 ad='int((1 + 1)/2) * 0.42 / 1 * 0.29'
+ as='int((1 + 2)/2) * 0.42 / 1 * 0.29' pd='2*int((1 + 1)/2) * (0.42 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (0.42 / 1 + 0.29)'
+ nrd='0.29 / 0.42 ' nrs='0.29 / 0.42 ' sa=0 sb=0 sd=0 mult=1 m=1
Vexp exp gnd 0
Vgnd gnd GND! 0
Vvdd vdd GND! {xvdd}
xpix2x2 gnd gnd gnd gnd gnd gnd gnd gnd vpd3 vpd2 vpd1 vpd0_in vdd gnd gnd vdd vdd gnd PrSFBp vdd
+ PrBp openDVS_pixel2x2
Bipd2 vpd0 gnd I = pow(10, v(exp))
CloadPD2 vpd0 gnd 'xCloadPD' m=1
Vmeas_ipd2 vpd0_in vpd0 0
I0 vpd1 gnd 'xipd1'
I1 vpd2 gnd 'xipd2'
I2 vpd3 gnd 'xipd3'
**** begin user architecture code

** opencircuitdesign pdks install
.lib $::SKYWATER_MODELS/sky130.lib.spice CACE{corner}



.include CACE{root}/xschem/openDVS_pixel2x2_CACE{xPexType}.spice

.temp CACE{temperature}

** Convergence options for Calibre RCC PEX (dense parasitics, 3k+ R, 1.6k+ C)
.option gmin=1e-12 abstol=1e-15 vntol=1e-6 reltol=1e-3 chgtol=1e-16
.option method=gear maxord=2 trtol=1
.option itl1=1000 itl2=500 itl4=100
.option gminsteps=500 srcsteps=500
.option ramptime=100n

.param xvdd = CACE{vdd}
.param xPrBp = CACE{xPrBp}
.param xPrSFBp = CACE{xPrSFBp}
.param xCloadPD = 30f
.param xipd1 = 1n
.param xipd2 = 1n
.param xipd3 = 1n

.save v(vdd) v(vpd0) v(vpd0_in) v(exp)
.save v(xpix2x2.xpix[0].vpr) v(xpix2x2.xpix[0].vsf)
.save v(xpix2x2.xpix[0].vdiff) v(xpix2x2.xpix[0].xchamp.vd)
.save v(xpix2x2.xpix[0].on) v(xpix2x2.xpix[0].noff) v(xpix2x2.xpix[0].nrst)

.control
dc Vexp -7 -12 -0.2
write CACE{filename}_CACE{N}.raw
shell python CACE{root}/cace/scripts/tb_PixelPhotoreceptor_dc_2x2.py CACE{simpath} CACE{filename} CACE{N}
.endc


**** end user architecture code
**.ends
.GLOBAL GND!
.end
