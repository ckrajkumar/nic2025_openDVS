** sch_path: analog/klayout/production/final_merge_20260923/testbenches/cace/analog/cace/templates/tb_BiasMasterBias_bootstrap.sch
**.subckt tb_BiasMasterBias_bootstrap
xBiasMasterBias VMasterBiasP Coarse2 Coarse1 VMasterBiasN PowerDown vdd gnd IR BiasMasterBias
Vgnd gnd GND! 0
.save i(vgnd)
Vvdd vdd GND! pwl(0 0 'xtramp' 'xvdd')
.save i(vvdd)
* noconn VMasterBiasP
* noconn Coarse1
* noconn Coarse2
* noconn VMasterBiasN
R1 IR gnd 'xIR' m=1
Vpd PowerDown gnd pwl(0 0 'xtramp' 'xvdd' 'xtpd_fall' 'xvdd' 'xtpd_fall+xtpd_tf' 0)
.save i(vpd)
**** begin user architecture code

** opencircuitdesign pdks install
.lib $::SKYWATER_MODELS/sky130.lib.spice CACE{corner}



.include CACE{DUT_path}

.temp CACE{temperature}

.option SEED=CACE[CACE{seed=12345} + CACE{iterations=0}]

* Flag unsafe operating conditions (exceeds models' specified limits)
.option warn=1

.param xvdd = CACE{vdd}
.param xtramp = 1m
.param xtpd_fall = 2m
.param xtpd_tf = 10u

.param xIR = 100k

.save all

.control
tran 1u 10m
write CACE{filename}_CACE{N}.raw
shell python CACE{root}/cace/scripts/tb_BiasMasterBias_bootstrap.py CACE{simpath} CACE{filename} CACE{N}
.endc


**** end user architecture code
**.ends

* expanding   symbol:  BiasMasterBias.sym # of pins=8
** sym_path: analog/xschem/BiasMasterBias.sym
** sch_path: analog/xschem/BiasMasterBias.sch
.subckt BiasMasterBias VMasterBiasP ICoarse2 ICoarse1 VMasterBiasN BiasPowerDown VddA18 GndA IR
*.opin VMasterBiasP
*.iopin IR
*.iopin VddA18
*.iopin GndA
*.opin VMasterBiasN
*.iopin ICoarse1
*.iopin ICoarse2
*.ipin BiasPowerDown
XMNBiasDio VMasterBiasN VMasterBiasN GndA GndA sky130_fd_pr__nfet_01v8_lvt L=5 W=20 nf=1 ad='int((1 +
+ 1)/2) * 20 / 1 * 0.29' as='int((1 + 2)/2) * 20 / 1 * 0.29' pd='2*int((1 + 1)/2) * (20 / 1 + 0.29)' ps='2*int((1
+ + 2)/2) * (20 / 1 + 0.29)' nrd='0.29 / 20 ' nrs='0.29 / 20 ' sa=0 sb=0 sd=0 mult=12 m=12
XMPBias VCasc VMasterBiasP VddA18 VddA18 sky130_fd_pr__pfet_01v8 L=20 W=2 nf=1 ad='int((1 + 1)/2) * 2
+ / 1 * 0.29' as='int((1 + 2)/2) * 2 / 1 * 0.29' pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 +
+ 2)/2) * (2 / 1 + 0.29)' nrd='0.29 / 2 ' nrs='0.29 / 2 ' sa=0 sb=0 sd=0 mult=8 m=8
XMNBias net1 VMasterBiasN IR GndA sky130_fd_pr__nfet_01v8_lvt L=5 W=20 nf=1 ad='int((1 + 1)/2) * 20 /
+ 1 * 0.29' as='int((1 + 2)/2) * 20 / 1 * 0.29' pd='2*int((1 + 1)/2) * (20 / 1 + 0.29)' ps='2*int((1 +
+ 2)/2) * (20 / 1 + 0.29)' nrd='0.29 / 20 ' nrs='0.29 / 20 ' sa=0 sb=0 sd=0 mult=16 m=16
XMnBiasCascDio VCasc VCasc VMasterBiasN GndA sky130_fd_pr__nfet_01v8_lvt L=20 W=1 nf=1 ad='int((1 + 1)/2)
+ * 1 / 1 * 0.29' as='int((1 + 2)/2) * 1 / 1 * 0.29' pd='2*int((1 + 1)/2) * (1 / 1 + 0.29)' ps='2*int((1
+ + 2)/2) * (1 / 1 + 0.29)' nrd='0.29 / 1 ' nrs='0.29 / 1 ' sa=0 sb=0 sd=0 mult=12 m=12
XMnBiasCasc VMasterBiasP VCasc net1 GndA sky130_fd_pr__nfet_01v8_lvt L=20 W=1 nf=1 ad='int((1 + 1)/2)
+ * 1 / 1 * 0.29' as='int((1 + 2)/2) * 1 / 1 * 0.29' pd='2*int((1 + 1)/2) * (1 / 1 + 0.29)' ps='2*int((1
+ + 2)/2) * (1 / 1 + 0.29)' nrd='0.29 / 1 ' nrs='0.29 / 1 ' sa=0 sb=0 sd=0 mult=16 m=16
XMPBiasDio VMasterBiasP VMasterBiasP VddA18 VddA18 sky130_fd_pr__pfet_01v8 L=20 W=2 nf=1 ad='int((1 +
+ 1)/2) * 2 / 1 * 0.29' as='int((1 + 2)/2) * 2 / 1 * 0.29' pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1
+ + 2)/2) * (2 / 1 + 0.29)' nrd='0.29 / 2 ' nrs='0.29 / 2 ' sa=0 sb=0 sd=0 mult=8 m=8
XMNMirr1 net2 VMasterBiasN GndA GndA sky130_fd_pr__nfet_01v8_lvt L=5 W=20 nf=1 ad='int((1 + 1)/2) * 20
+ / 1 * 0.29' as='int((1 + 2)/2) * 20 / 1 * 0.29' pd='2*int((1 + 1)/2) * (20 / 1 + 0.29)' ps='2*int((1
+ + 2)/2) * (20 / 1 + 0.29)' nrd='0.29 / 20 ' nrs='0.29 / 20 ' sa=0 sb=0 sd=0 mult=1 m=1
XMNMirrCasc1 ICoarse1 VCasc net2 GndA sky130_fd_pr__nfet_01v8_lvt L=20 W=1 nf=1 ad='int((1 + 1)/2) *
+ 1 / 1 * 0.29' as='int((1 + 2)/2) * 1 / 1 * 0.29' pd='2*int((1 + 1)/2) * (1 / 1 + 0.29)' ps='2*int((1
+ + 2)/2) * (1 / 1 + 0.29)' nrd='0.29 / 1 ' nrs='0.29 / 1 ' sa=0 sb=0 sd=0 mult=1 m=1
XMNMirr2 net3 VMasterBiasN GndA GndA sky130_fd_pr__nfet_01v8_lvt L=5 W=20 nf=1 ad='int((1 + 1)/2) * 20
+ / 1 * 0.29' as='int((1 + 2)/2) * 20 / 1 * 0.29' pd='2*int((1 + 1)/2) * (20 / 1 + 0.29)' ps='2*int((1
+ + 2)/2) * (20 / 1 + 0.29)' nrd='0.29 / 20 ' nrs='0.29 / 20 ' sa=0 sb=0 sd=0 mult=1 m=1
XMNMirrCasc2 ICoarse2 VCasc net3 GndA sky130_fd_pr__nfet_01v8_lvt L=20 W=1 nf=1 ad='int((1 + 1)/2) *
+ 1 / 1 * 0.29' as='int((1 + 2)/2) * 1 / 1 * 0.29' pd='2*int((1 + 1)/2) * (1 / 1 + 0.29)' ps='2*int((1
+ + 2)/2) * (1 / 1 + 0.29)' nrd='0.29 / 1 ' nrs='0.29 / 1 ' sa=0 sb=0 sd=0 mult=1 m=1
XMNBSPD VCasc BiasPowerDown GndA GndA sky130_fd_pr__nfet_01v8_lvt L=0.2 W=2 nf=1 ad='int((1 + 1)/2) *
+ 2 / 1 * 0.29' as='int((1 + 2)/2) * 2 / 1 * 0.29' pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1
+ + 2)/2) * (2 / 1 + 0.29)' nrd='0.29 / 2 ' nrs='0.29 / 2 ' sa=0 sb=0 sd=0 mult=1 m=1
XMNBSCapBias VddA18 VMasterBiasP VddA18 GndA sky130_fd_pr__nfet_01v8 L=16 W=16 nf=1 ad='int((1 + 1)/2)
+ * 16 / 1 * 0.29' as='int((1 + 2)/2) * 16 / 1 * 0.29' pd='2*int((1 + 1)/2) * (16 / 1 + 0.29)' ps='2*int((1
+ + 2)/2) * (16 / 1 + 0.29)' nrd='0.29 / 16 ' nrs='0.29 / 16 ' sa=0 sb=0 sd=0 mult=1 m=1
XMPBS bootstrap VMasterBiasP VddA18 VddA18 sky130_fd_pr__pfet_01v8 L=0.2 W=2 nf=1 ad='int((1 + 1)/2)
+ * 2 / 1 * 0.29' as='int((1 + 2)/2) * 2 / 1 * 0.29' pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1
+ + 2)/2) * (2 / 1 + 0.29)' nrd='0.29 / 2 ' nrs='0.29 / 2 ' sa=0 sb=0 sd=0 mult=1 m=1
XMNBSCapBS BiasPowerDown bootstrap BiasPowerDown GndA sky130_fd_pr__nfet_01v8 L=16 W=16 nf=1 ad='int((1
+ + 1)/2) * 16 / 1 * 0.29' as='int((1 + 2)/2) * 16 / 1 * 0.29' pd='2*int((1 + 1)/2) * (16 / 1 + 0.29)' ps='2*int((1
+ + 2)/2) * (16 / 1 + 0.29)' nrd='0.29 / 16 ' nrs='0.29 / 16 ' sa=0 sb=0 sd=0 mult=1 m=1
XMPBSPU VCasc bootstrap VddA18 VddA18 sky130_fd_pr__pfet_01v8 L=0.2 W=2 nf=1 ad='int((1 + 1)/2) * 2 /
+ 1 * 0.29' as='int((1 + 2)/2) * 2 / 1 * 0.29' pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2)
+ * (2 / 1 + 0.29)' nrd='0.29 / 2 ' nrs='0.29 / 2 ' sa=0 sb=0 sd=0 mult=1 m=1
.ends

.GLOBAL GND!
.end
