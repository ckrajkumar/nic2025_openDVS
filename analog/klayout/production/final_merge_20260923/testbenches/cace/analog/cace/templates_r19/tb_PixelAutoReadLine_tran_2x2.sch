** sch_path: analog/klayout/production/final_merge_20260923/testbenches/cace/analog/cace/templates_r19/tb_PixelAutoReadLine_tran_2x2.sch
**.subckt tb_PixelAutoReadLine_tran_2x2
Vgnd gnd GND! 0
Vvdd vdd GND! {xvdd}
Iipd vpd0 gnd {xipd}
IRefrBp RefrBp gnd {xRefrBp}
XMRefrBp RefrBp RefrBp vdd vdd sky130_fd_pr__pfet_01v8 L=8 W=2 nf=1 ad='int((1 + 1)/2) * 2 / 1 * 0.29'
+ as='int((1 + 2)/2) * 2 / 1 * 0.29' pd='2*int((1 + 1)/2) * (2 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (2 / 1 + 0.29)'
+ nrd='0.29 / 2 ' nrs='0.29 / 2 ' sa=0 sb=0 sd=0 mult=1 m=1
IPrBp PrBp gnd {xPrBp}
XMPrBp PrBp PrBp vdd vdd sky130_fd_pr__pfet_01v8_hvt L=0.15 W=1 nf=1 ad='int((1 + 1)/2) * 1 / 1 * 0.29'
+ as='int((1 + 2)/2) * 1 / 1 * 0.29' pd='2*int((1 + 1)/2) * (1 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (1 / 1 + 0.29)'
+ nrd='0.29 / 1 ' nrs='0.29 / 1 ' sa=0 sb=0 sd=0 mult=1 m=1
IPrSFBp PrSFBp gnd {xPrSFBp}
XMDiffBn DiffBn DiffBn gnd gnd sky130_fd_pr__nfet_01v8 L=2 W=1 nf=1 ad='int((1 + 1)/2) * 1 / 1 * 0.29'
+ as='int((1 + 2)/2) * 1 / 1 * 0.29' pd='2*int((1 + 1)/2) * (1 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (1 / 1 + 0.29)'
+ nrd='0.29 / 1 ' nrs='0.29 / 1 ' sa=0 sb=0 sd=0 mult=1 m=1
IDiffBn vdd DiffBn {xDiffBn}
XMOnBn OnBn OnBn gnd gnd sky130_fd_pr__nfet_01v8 L=2 W=1 nf=1 ad='int((1 + 1)/2) * 1 / 1 * 0.29' as='int((1 + 2)/2) * 1 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (1 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (1 / 1 + 0.29)' nrd='0.29 / 1 ' nrs='0.29 / 1 '
+ sa=0 sb=0 sd=0 mult=1 m=1
IOnBn vdd OnBn {xOnBn}
XMOffBn OffBn OffBn gnd gnd sky130_fd_pr__nfet_01v8 L=2 W=1 nf=1 ad='int((1 + 1)/2) * 1 / 1 * 0.29' as='int((1 + 2)/2) * 1 / 1 * 0.29'
+ pd='2*int((1 + 1)/2) * (1 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (1 / 1 + 0.29)' nrd='0.29 / 1 ' nrs='0.29 / 1 '
+ sa=0 sb=0 sd=0 mult=1 m=1
IOffBn vdd OffBn {xOffBn}
CloadReadLine readLine gnd 'xCloadReadLine' m=1
CloadPD vpd0 gnd 'xCloadPD' m=1
Vmeas_ipd vpd0_in vpd0 0
XMPrSFBp PrSFBp PrSFBp vdd vdd sky130_fd_pr__pfet_01v8 L=8 W=1 nf=2 ad='int((2 + 1)/2) * 1 / 2 * 0.29'
+ as='int((2 + 2)/2) * 1 / 2 * 0.29' pd='2*int((2 + 1)/2) * (1 / 2 + 0.29)' ps='2*int((2 + 2)/2) * (1 / 2 + 0.29)'
+ nrd='0.29 / 1 ' nrs='0.29 / 1 ' sa=0 sb=0 sd=0 mult=1 m=1
RreadLinePU vdd readLine 10k m=1
VpixRstCtrl pixRst gnd 0
VrowReadON rowReadON gnd 0
VrowReadOFF rowReadOFF gnd 0
xpix2x2 gnd pixRst gnd rowReadON gnd rowReadOFF vdd readLine vpd3 vpd2 vpd1 vpd0_in vdd gnd gnd OnBn
+ OffBn DiffBn PrSFBp RefrBp PrBp openDVS_pixel2x2
I0 vpd1 gnd 'xipd1'
I1 vpd2 gnd 'xipd2'
I2 vpd3 gnd 'xipd3'
**** begin user architecture code

** opencircuitdesign pdks install
.lib $::SKYWATER_MODELS/sky130.lib.spice CACE{corner}



.include CACE{root}/xschem/openDVS_pixel2x2_CACE{xPexType}_CACE{corner}.spice

.temp CACE{temperature}

** Convergence options for nA-range weak-inversion pixel circuit
.option gmin=1e-16 abstol=1e-15 vntol=1e-9 reltol=1e-4 chgtol=1e-16
.option method=gear maxord=2 trtol=1
.option itl1=500 itl2=200 itl4=50
.option gminsteps=200 srcsteps=200
.option ramptime=100n

.param xvdd = CACE{vdd}
.param xipd = CACE{xipd}
.param xipd1 = CACE{xipd1}
.param xipd2 = CACE{xipd2}
.param xipd3 = CACE{xipd3}
.param xPrBp = CACE{xPrBp}
.param xPrSFBp = CACE{xPrSFBp}
.param xRefrBp = CACE{xRefrBp}
.param xDiffBn = CACE{xDiffBn}
.param xOnBn = CACE{xOnBn}
.param xOffBn = CACE{xOffBn}

.param xCloadPD = 30f
.param xCloadReadLine = 300f

*Small Iphoto testing on Pix[0]
Iphoto1 vpd0 gnd pulse(50n 100n 120m 50m 50m 59.9m 300m)
Iphoto2 vpd0 gnd pulse(50n 25n 240m 50m 50m 59.9m 300m)

** Bsource probes: mirror internal nodes to top-level names (brackets OK in SPICE deck)
** PEX cc netlist uses xPix[N] instance names, so full path is xpix2x2.xpix[0].*
Bprobe_on on_mon 0 V = v(xpix2x2.xdiffbn_physical_core.opendvs_pixel_0.on)
Bprobe_noff noff_mon 0 V = v(xpix2x2.xdiffbn_physical_core.opendvs_pixel_0.noff)
Bprobe_vdiff vdiff_mon 0 V = v(xpix2x2.xdiffbn_physical_core.opendvs_pixel_0.vdiff)

** Save Bsource monitor nodes + xPix[0] internals (no parasitic _N nodes)
.save v(vdd) v(on_mon) v(noff_mon) v(vdiff_mon) v(pixrst) v(readLine) v(rowreadon) v(rowreadoff)
.save v(xpix2x2.xdiffbn_physical_core.opendvs_pixel_0.vpr) v(xpix2x2.xdiffbn_physical_core.opendvs_pixel_0.vsf)
.save v(xpix2x2.xdiffbn_physical_core.opendvs_pixel_0.vdiff) v(xpix2x2.xdiffbn_physical_core.opendvs_pixel_0.vd)
.save v(xpix2x2.xdiffbn_physical_core.opendvs_pixel_0.on) v(xpix2x2.xdiffbn_physical_core.opendvs_pixel_0.noff) v(xpix2x2.xdiffbn_physical_core.opendvs_pixel_0.nrst)

.control

** ============================================================
** Event-driven auto-read testbench
** Detects xpix.ON rising or xpix.nOFF falling, then generates
** the read sequence: rowReadON, rowReadOFF, rowReadON (reset)
** ============================================================

** Read sequence timing (parameterizable)
let xevent_delay = 1e-6
let xread_on_len = 950e-9
let xgap = 50e-9
let xread_off_len = 950e-9
let xrst_phase_len = 950e-9
let xsettle = 100e-6

let sim_end = 0.39
let tran_end = sim_end + 1

** Phase 0: let circuit initialize (10ms settling)
** tran end time must exceed sim_end to avoid resume-after-finished crash
stop when time > 10e-3
tran 1u $&tran_end uic
let vdd_val = v(vdd)[length(v(vdd))-1]
let on_thresh = 0.9 * vdd_val
let noff_thresh = 0.1 * vdd_val

echo
echo '=== Auto-read TB initialized ==='
echo '    VDD =' $&vdd_val 'V'
echo '    ON thresh =' $&on_thresh 'V'
echo '    nOFF thresh =' $&noff_thresh 'V'

** Event-driven readout loop (runs until sim_end)
let event_count = 0
let t_now = time[length(time)-1]

while t_now < $&sim_end - 1e-9
  ** Arm event breakpoints
  delete all
  stop when v(on_mon) > $&on_thresh
  stop when v(noff_mon) < $&noff_thresh
  stop when time > $&sim_end
  resume

  let t_now = time[length(time)-1]
  if t_now >= $&sim_end - 1e-9
    break
  end

  let event_count = event_count + 1
  let t_event = t_now
  echo
  echo '=== Event #' $&event_count 'at t =' $&t_event 's ==='

  ** Skip read sequence if not enough time left
  let t_seq_end = t_event + xevent_delay + xread_on_len + xgap + xread_off_len + xgap +
+ xrst_phase_len + xsettle
  if t_seq_end > $&sim_end
    echo '    Skipping read sequence - too close to sim_end'
    break
  end

  ** Wait parameterized delay before read sequence
  delete all
  let t1 = t_event + xevent_delay
  stop when time > $&t1
  resume

  ** Phase 1: rowReadON (read ON phase)
  alter vrowreadon = $&vdd_val
  delete all
  let t2 = t1 + xread_on_len
  stop when time > $&t2
  resume
  alter vrowreadon = 0

  ** Gap
  delete all
  let t3 = t2 + xgap
  stop when time > $&t3
  resume

  ** Phase 2: rowReadOFF
  alter vrowreadoff = $&vdd_val
  delete all
  let t4 = t3 + xread_off_len
  stop when time > $&t4
  resume
  alter vrowreadoff = 0

  ** Gap
  delete all
  let t5 = t4 + xgap
  stop when time > $&t5
  resume

  ** Phase 3: rowReadON (reset phase) + pixRst
  alter vrowreadon = $&vdd_val
  alter vpixrstctrl = $&vdd_val
  delete all
  let t6 = t5 + xrst_phase_len
  stop when time > $&t6
  resume
  alter vrowreadon = 0
  alter vpixrstctrl = 0

  ** Post-reset settle before re-arming event detection
  delete all
  let t7 = t6 + xsettle
  stop when time > $&t7
  resume
  let t_now = time[length(time)-1]
end

** Run to sim_end to ensure complete waveform
delete all
stop when time > $&sim_end
resume

echo
echo '=== Simulation complete:' $&event_count 'events detected ==='
setplot tran1
write CACE{filename}_CACE{N}.raw

shell python3 CACE{root}/cace/scripts/tb_PixelAutoReadLine_tran_2x2.py CACE{simpath} CACE{filename} CACE{N}
.endc


**** end user architecture code
**.ends
.GLOBAL GND!
.end
