** sch_path: analog/klayout/production/final_merge_20260923/testbenches/cace/analog/cace/templates/tb_BiasCoarseBuffer.sch
**.subckt tb_BiasCoarseBuffer
xBiasMasternCoarse vdd gnd BiasCB<0> BiasCB<1> BiasCB<3> BiasCB<4> BiasCB<5> BiasCB<6> BiasCB<7>
+ BiasCB<2> PowerDown VmasterN VmasterP IR BiasMasternCoarse
Vgnd gnd GND! 0
.save i(vgnd)
Vvdd vdd GND! 'xvdd'
.save i(vvdd)
R1 IR gnd 'xIR' m=1
VpowerDown PowerDown gnd 'xpowerdown*xvdd'
.save i(vpowerdown)
* noconn VmasterN
* noconn VmasterP
xCoarseBuf vdd gnd bit0 bit1 bit2 VGate BiasCB<0> BiasCB<1> BiasCB<3> BiasCB<4> BiasCB<5> BiasCB<6>
+ BiasCB<7> BiasCB<2> BiasCoarseBuffer
xCoarse2Fine vdd gnd bit1 bit2 VGate_meas gnd BiasCoarseFineInterface
Vmeas_ICoarse VGate_meas VGate 0
.save i(vmeas_icoarse)
Vbit0 bit0 gnd 'xbit0*xvdd'
.save i(vbit0)
Vbit1 bit1 gnd 'xbit1*xvdd'
.save i(vbit1)
Vbit2 bit2 gnd 'xbit2*xvdd'
.save i(vbit2)
**** begin user architecture code

** opencircuitdesign pdks install
.lib $::SKYWATER_MODELS/sky130.lib.spice tt



.include CACE{DUT_path}
.include CACE{root}/netlist/schematic/BiasCoarseFineInterface.spice
.include CACE{root}/netlist/schematic/BiasMasternCoarse.spice

xBiasMasternCoarse vdd gnd BiasCB<0> BiasCB<1> BiasCB<3> BiasCB<4> BiasCB<5> BiasCB<6> BiasCB<7>
+ BiasCB<2> PowerDown VmasterN  VmasterP IR BiasMasternCoarse
xCoarse2Fine vdd gnd bit1 bit2 VGate_meas gnd BiasCoarseFineInterface


.temp CACE{temperature}

.option SEED=CACE[CACE{seed=12345} + CACE{iterations=0}]

* Flag unsafe operating conditions (exceeds models' specified limits)
.option warn=1

.param xvdd = CACE{vdd}
.param xpowerdown = 0
.param xIR = 100k
.param xcoarseCode = CACE{coarseCode}
.param xbit0 = (xcoarseCode%2 >= 1)?1:0
.param xbit1 = ((xcoarseCode/2)%2 >= 1)?1:0
.param xbit2 = ((xcoarseCode/4)%2 >= 1)?1:0

.save all

.control
op
write CACE{filename}_CACE{N}.raw
shell python CACE{root}/cace/scripts/tb_BiasCoarseBuffer_op.py CACE{simpath} CACE{filename} CACE{N}
.endc


**** end user architecture code
**.ends
.GLOBAL GND!
.end
