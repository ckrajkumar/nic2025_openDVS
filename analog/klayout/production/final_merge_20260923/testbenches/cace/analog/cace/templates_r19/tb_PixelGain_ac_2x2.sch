** sch_path: analog/klayout/production/final_merge_20260923/testbenches/cace/analog/cace/templates_r19/tb_PixelGain_ac_2x2.sch
**.subckt tb_PixelGain_ac_2x2
Vgnd gnd GND! 0
Vvdd vdd GND! {xvdd}
Iipd vpd0 gnd dc {xipd} ac {xipd}
Vmeas_ipd1 vpd0_in vpd0 0
XMDiffBn DiffBn DiffBn gnd gnd sky130_fd_pr__nfet_01v8 L=1.5 W=1.5 nf=1 ad='int((1 + 1)/2) * 1.5 / 1 * 0.29'
+ as='int((1 + 2)/2) * 1.5 / 1 * 0.29' pd='2*int((1 + 1)/2) * (1.5 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (1.5 / 1 + 0.29)'
+ nrd='0.29 / 1.5 ' nrs='0.29 / 1.5 ' sa=0 sb=0 sd=0 mult=1 m=1
IDiffBn vdd DiffBn {xDiffBn}
IPrBp PrBp gnd {xPrBp}
XMPrBp PrBp PrBp vdd vdd sky130_fd_pr__pfet_01v8 L=0.15 W=0.5 nf=1 ad='int((1 + 1)/2) * 0.5 / 1 * 0.29'
+ as='int((1 + 2)/2) * 0.5 / 1 * 0.29' pd='2*int((1 + 1)/2) * (0.5 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (0.5 / 1 + 0.29)'
+ nrd='0.29 / 0.5 ' nrs='0.29 / 0.5 ' sa=0 sb=0 sd=0 mult=1 m=1
IPrSFBp PrSFBp gnd {xPrSFBp}
XMPrSFBp PrSFBp PrSFBp vdd vdd sky130_fd_pr__pfet_01v8 L=1.5 W=0.42 nf=1 ad='int((1 + 1)/2) * 0.42 / 1 * 0.29'
+ as='int((1 + 2)/2) * 0.42 / 1 * 0.29' pd='2*int((1 + 1)/2) * (0.42 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (0.42 / 1 + 0.29)'
+ nrd='0.29 / 0.42 ' nrs='0.29 / 0.42 ' sa=0 sb=0 sd=0 mult=1 m=1
xpix2x2 gnd gnd gnd gnd gnd gnd gnd gnd vpd3 vpd2 vpd1 vpd0_in vdd gnd gnd vdd vdd DiffBn PrSFBp vdd
+ PrBp openDVS_pixel2x2
**** begin user architecture code

** opencircuitdesign pdks install
.lib $::SKYWATER_MODELS/sky130.lib.spice CACE{corner}



.include CACE{root}/xschem/openDVS_pixel2x2_CACE{xPexType}_CACE{corner}.spice

.temp CACE{temperature}

.option gmin=1e-16 abstol=1e-15 vntol=1e-9 reltol=1e-4 chgtol=1e-16
.option itl1=500 itl2=200
.option gminsteps=200 srcsteps=200

.param xvdd = CACE{vdd}
.param xipd = CACE{xipd}
.param xPrBp = CACE{xPrBp}
.param xPrSFBp = CACE{xPrSFBp}
.param xDiffBn = CACE{xDiffBn}
.param xCloadPD = CACE{xCloadPD}

** DC current sources for neighbor pixels (no AC stimulus)
Iipd1 vpd1 gnd dc {xipd}
Iipd2 vpd2 gnd dc {xipd}
Iipd3 vpd3 gnd dc {xipd}

** Large inductor: DC short (sets OP) but AC open (no effect on freq response)
** Provides DC path for floating cap node vd through vdiff in ALL 4 pixels
Lbias0 xpix2x2.xdiffbn_physical_core.opendvs_pixel_0.vdiff
+ xpix2x2.xdiffbn_physical_core.opendvs_pixel_0.vd 1000T
Lbias1 xpix2x2.xdiffbn_physical_core.opendvs_pixel_1.vdiff
+ xpix2x2.xdiffbn_physical_core.opendvs_pixel_1.vd 1000T
Lbias2 xpix2x2.xdiffbn_physical_core.opendvs_pixel_2.vdiff
+ xpix2x2.xdiffbn_physical_core.opendvs_pixel_2.vd 1000T
Lbias3 xpix2x2.xdiffbn_physical_core.opendvs_pixel_3.vdiff
+ xpix2x2.xdiffbn_physical_core.opendvs_pixel_3.vd 1000T

** DC path for nRst nodes (RefrBp=vdd turns off current source, leaving nRst floating)
Rfix_nRst0 xpix2x2.xdiffbn_physical_core.opendvs_pixel_0.nRst vdd 1T
Rfix_nRst1 xpix2x2.xdiffbn_physical_core.opendvs_pixel_1.nRst vdd 1T
Rfix_nRst2 xpix2x2.xdiffbn_physical_core.opendvs_pixel_2.nRst vdd 1T
Rfix_nRst3 xpix2x2.xdiffbn_physical_core.opendvs_pixel_3.nRst vdd 1T

** Bsource probes: mirror bracket-containing internal nodes to top-level names
Bprobe_vpd vpd_mon 0 V = v(vpd0_in)
Bprobe_vpr vpr_mon 0 V = v(xpix2x2.xdiffbn_physical_core.opendvs_pixel_0.vpr)
Bprobe_vsf vsf_mon 0 V = v(xpix2x2.xdiffbn_physical_core.opendvs_pixel_0.vsf)
Bprobe_vdiff vdiff_mon 0 V = v(xpix2x2.xdiffbn_physical_core.opendvs_pixel_0.vdiff)
Bprobe_vd vd_mon 0 V = v(xpix2x2.xdiffbn_physical_core.opendvs_pixel_0.vd)

** Save Bsource monitor nodes + xPix[0] internals (no parasitic _N nodes)
.save v(vdd) v(vpd0_in) v(vpr_mon) v(vsf_mon) v(vdiff_mon) v(vd_mon)
.save v(xpix2x2.xdiffbn_physical_core.opendvs_pixel_0.vpr) v(xpix2x2.xdiffbn_physical_core.opendvs_pixel_0.vsf)
.save v(xpix2x2.xdiffbn_physical_core.opendvs_pixel_0.vdiff) v(xpix2x2.xdiffbn_physical_core.opendvs_pixel_0.vd)
.save v(xpix2x2.xdiffbn_physical_core.opendvs_pixel_0.on) v(xpix2x2.xdiffbn_physical_core.opendvs_pixel_0.noff) v(xpix2x2.xdiffbn_physical_core.opendvs_pixel_0.nrst)

.control
** OP with nRst=vdd, inductor provides DC path for floating nodes
op
write CACE{filename}_CACE{N}_op.raw

** AC sweep from this operating point
ac dec 50 1m 1G
write CACE{filename}_CACE{N}.raw

echo
echo '=== AC analysis complete, running post-processing ==='
shell python3 CACE{root}/cace/scripts/tb_PixelGain_ac_2x2.py CACE{simpath} CACE{filename} CACE{N}
.endc


**** end user architecture code
**.ends
.GLOBAL GND!
.end
