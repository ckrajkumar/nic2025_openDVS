** sch_path: analog/klayout/production/final_merge_20260923/testbenches/cace/analog/cace/templates_calibre/tb_PixelComparators_dc_2x2.sch
**.subckt tb_PixelComparators_dc_2x2
XMOnBn OnBn OnBn gnd gnd sky130_fd_pr__nfet_01v8 L=1.5 W=1.5 nf=1 ad='int((1 + 1)/2) * 1.5 / 1 * 0.29'
+ as='int((1 + 2)/2) * 1.5 / 1 * 0.29' pd='2*int((1 + 1)/2) * (1.5 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (1.5 / 1 + 0.29)'
+ nrd='0.29 / 1.5 ' nrs='0.29 / 1.5 ' sa=0 sb=0 sd=0 mult=1 m=1
IOnBn vdd OnBn {xOnBn}
XMOffBn OffBn OffBn gnd gnd sky130_fd_pr__nfet_01v8 L=1.5 W=1.5 nf=1 ad='int((1 + 1)/2) * 1.5 / 1 * 0.29'
+ as='int((1 + 2)/2) * 1.5 / 1 * 0.29' pd='2*int((1 + 1)/2) * (1.5 / 1 + 0.29)' ps='2*int((1 + 2)/2) * (1.5 / 1 + 0.29)'
+ nrd='0.29 / 1.5 ' nrs='0.29 / 1.5 ' sa=0 sb=0 sd=0 mult=1 m=1
IOffBn vdd OffBn {xOffBn}
Vgnd1 gnd GND! 0
Vvdd1 vdd GND! {xvdd}
xpix2x2 gnd gnd gnd gnd gnd gnd gnd gnd vpd3 vpd2 vpd1 vpd0 vdd gnd gnd OnBn OffBn gnd vdd gnd gnd
+ openDVS_pixel2x2
I0 vpd1 gnd 'xipd1'
I1 vpd2 gnd 'xipd2'
I2 vpd3 gnd 'xipd3'
I3 vpd0 gnd 'xipd0'
**** begin user architecture code

** opencircuitdesign pdks install
.lib $::SKYWATER_MODELS/sky130.lib.spice CACE{corner}



.include CACE{root}/xschem/openDVS_pixel2x2_CACE{xPexType}.spice

.temp CACE{temperature}

.option gmin=1e-16 abstol=1e-15 vntol=1e-9 reltol=1e-4 chgtol=1e-16
.option itl1=500 itl2=200
.option gminsteps=200 srcsteps=200

.param xvdd = CACE{vdd}
** Bias set: 1 = OnBn=200nA / OffBn=0.5nA, 2 = OnBn=100nA / OffBn=1nA
.param xBiasSet = CACE{xBiasSet}
.param xOnBn = '(xBiasSet < 1.5) ? 200e-9 : 100e-9'
.param xOffBn = '(xBiasSet < 1.5) ? 0.5e-9 : 1e-9'

.param xipd0 = CACE{xipd0}
.param xipd1 = CACE{xipd1}
.param xipd2 = CACE{xipd2}
.param xipd3 = CACE{xipd3}

** Force vdiff on Pix[0] — must be in SPICE code, not as schematic wire
** (xschem mangles dots in net labels during netlisting)
Vvdiff_pex xpix2x2.xPix[0].vdiff gnd {xvdiff}

** Bsource probes: mirror bracket-containing internal nodes to top-level names
** PEX cc netlist uses xPix[N] instance names, so full path is xpix2x2.xpix[0].*
Bprobe_on on_mon 0 V = v(xpix2x2.xpix[0].on)
Bprobe_noff noff_mon 0 V = v(xpix2x2.xpix[0].noff)

.param xvdiff = 0

** Save Bsource monitor nodes + xPix[0] internals (no parasitic _N nodes)
.save v(vdd) v(on_mon) v(noff_mon)
.save v(xpix2x2.xpix[0].vpr) v(xpix2x2.xpix[0].vsf)
.save v(xpix2x2.xpix[0].vdiff) v(xpix2x2.xpix[0].vd)
.save v(xpix2x2.xpix[0].on) v(xpix2x2.xpix[0].noff) v(xpix2x2.xpix[0].nrst)
.save v(xpix2x2.xpix[0].net46) v(xpix2x2.xpix[0].net47) v(xpix2x2.xpix[0].net48)
.save v(xpix2x2.xpix[0].mmpr.amp.d) v(xpix2x2.xpix[0].mmpr.amp.g) v(xpix2x2.xpix[0].mmpr.amp.s)
.save v(xpix2x2.xpix[0].mmpd.d) v(xpix2x2.xpix[0].mmpd.g) v(xpix2x2.xpix[0].mmpd.s)
.save v(xpix2x2.xpix[0].mmprbias.d) v(xpix2x2.xpix[0].mmprbias.g) v(xpix2x2.xpix[0].mmprbias.s)
.save v(xpix2x2.xpix[0].mmsf.d) v(xpix2x2.xpix[0].mmsf.g) v(xpix2x2.xpix[0].mmsf.s)
.save v(xpix2x2.xpix[0].mmchamp.d) v(xpix2x2.xpix[0].mmchamp.g) v(xpix2x2.xpix[0].mmchamp.s)
.save v(xpix2x2.xpix[0].mmchampbias.d) v(xpix2x2.xpix[0].mmchampbias.g) v(xpix2x2.xpix[0].mmchampbias.s)
.save v(xpix2x2.xpix[0].mmcapref.d) v(xpix2x2.xpix[0].mmcapref.g) v(xpix2x2.xpix[0].mmcapref.s)
.save v(xpix2x2.xpix[0].mmrst.d) v(xpix2x2.xpix[0].mmrst.g) v(xpix2x2.xpix[0].mmrst.s)
.save v(xpix2x2.xpix[0].mmp0.d) v(xpix2x2.xpix[0].mmp0.g) v(xpix2x2.xpix[0].mmp0.s)
.save v(xpix2x2.xpix[0].mmrefrbias.d) v(xpix2x2.xpix[0].mmrefrbias.g) v(xpix2x2.xpix[0].mmrefrbias.s)
.save v(xpix2x2.xpix[0].mmpdrefrcol.d) v(xpix2x2.xpix[0].mmpdrefrcol.g)
.save v(xpix2x2.xpix[0].mmpdrefrrow.g) v(xpix2x2.xpix[0].mmpdrefrrow.s)
.save v(xpix2x2.xpix[0].mmon.d) v(xpix2x2.xpix[0].mmon.g) v(xpix2x2.xpix[0].mmon.s)
.save v(xpix2x2.xpix[0].mmonbias.d) v(xpix2x2.xpix[0].mmonbias.g) v(xpix2x2.xpix[0].mmonbias.s)
.save v(xpix2x2.xpix[0].mmp2.d) v(xpix2x2.xpix[0].mmp2.g) v(xpix2x2.xpix[0].mmp2.s)
.save v(xpix2x2.xpix[0].mmoffbias.d) v(xpix2x2.xpix[0].mmoffbias.g) v(xpix2x2.xpix[0].mmoffbias.s)
.save v(xpix2x2.xpix[0].mmn7.g) v(xpix2x2.xpix[0].mmn7.s)
.save v(xpix2x2.xpix[0].mmn8.g) v(xpix2x2.xpix[0].mmn8.s)
.save v(xpix2x2.xpix[0].mmn10.d) v(xpix2x2.xpix[0].mmn10.g)
.save v(xpix2x2.xpix[0].mmn11.d) v(xpix2x2.xpix[0].mmn11.g)

.control
dc vvdiff_pex 0 CACE{vdd} 0.1m
write CACE{filename}_CACE{N}.raw

shell python3 CACE{root}/cace/scripts/tb_PixelComparators_dc_2x2.py CACE{simpath} CACE{filename} CACE{N}
.endc


**** end user architecture code
**.ends
.GLOBAL GND!
.end
