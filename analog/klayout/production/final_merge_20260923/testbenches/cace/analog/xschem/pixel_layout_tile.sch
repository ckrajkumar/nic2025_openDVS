v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
N -80 -400 -0 -400 {lab=VDD}
N -80 -380 0 -380 {lab=GND}
N -80 -360 0 -360 {lab=GND}
N -80 -180 0 -180 {lab=rowReadON[0]}
N -80 -160 0 -160 {lab=rowReadOFF[0]}
N -80 -140 0 -140 {lab=rowReadON[1]}
N -80 -320 0 -320 {lab=DiffBn}
N -80 -300 0 -300 {lab=RefrBp}
N -80 -280 0 -280 {lab=PrSFBp}
N -80 -260 0 -260 {lab=OffBn}
N -80 -240 0 -240 {lab=PrBp}
N -80 -220 0 -220 {lab=OnBn}
N -80 -120 0 -120 {lab=rowReadOFF[1]}
N -80 340 0 340 {lab=rowReadON[2]}
N -80 360 0 360 {lab=rowReadOFF[2]}
N -80 380 0 380 {lab=rowReadON[3]}
N -80 400 0 400 {lab=rowReadOFF[3]}
N -80 860 0 860 {lab=rowReadON[4]}
N -80 880 0 880 {lab=rowReadOFF[4]}
N -80 900 0 900 {lab=rowReadON[5]}
N -80 920 0 920 {lab=rowReadOFF[5]}
N -80 1380 0 1380 {lab=rowReadON[6]}
N -80 1400 0 1400 {lab=rowReadOFF[6]}
N -80 1420 0 1420 {lab=rowReadON[7]}
N -80 1440 0 1440 {lab=rowReadOFF[7]}
N -80 1900 0 1900 {lab=rowReadON[8]}
N -80 1920 0 1920 {lab=rowReadOFF[8]}
N -80 1940 0 1940 {lab=rowReadON[9]}
N -80 1960 0 1960 {lab=rowReadOFF[9]}
N -80 2420 0 2420 {lab=rowReadON[10]}
N -80 2440 0 2440 {lab=rowReadOFF[10]}
N -80 2460 0 2460 {lab=rowReadON[11]}
N -80 2480 0 2480 {lab=rowReadOFF[11]}
N -80 2940 0 2940 {lab=rowReadON[12]}
N -80 2960 0 2960 {lab=rowReadOFF[12]}
N -80 2980 0 2980 {lab=rowReadON[13]}
N -80 3000 0 3000 {lab=rowReadOFF[13]}
N -80 3460 0 3460 {lab=rowReadON[14]}
N -80 3480 0 3480 {lab=rowReadOFF[14]}
N -80 3500 0 3500 {lab=rowReadON[15]}
N -80 3520 0 3520 {lab=rowReadOFF[15]}
N -80 3980 0 3980 {lab=rowReadON[16]}
N -80 4000 0 4000 {lab=rowReadOFF[16]}
N -80 4020 0 4020 {lab=rowReadON[17]}
N -80 4040 0 4040 {lab=rowReadOFF[17]}
N -80 4500 0 4500 {lab=rowReadON[18]}
N -80 4520 0 4520 {lab=rowReadOFF[18]}
N -80 4540 0 4540 {lab=rowReadON[19]}
N -80 4560 0 4560 {lab=rowReadOFF[19]}
N -80 5020 0 5020 {lab=rowReadON[20]}
N -80 5040 0 5040 {lab=rowReadOFF[20]}
N -80 5060 0 5060 {lab=rowReadON[21]}
N -80 5080 0 5080 {lab=rowReadOFF[21]}
N -80 5540 0 5540 {lab=rowReadON[22]}
N -80 5560 0 5560 {lab=rowReadOFF[22]}
N -80 5580 0 5580 {lab=rowReadON[23]}
N -80 5600 0 5600 {lab=rowReadOFF[23]}
N -80 6060 0 6060 {lab=rowReadON[24]}
N -80 6080 0 6080 {lab=rowReadOFF[24]}
N -80 6100 0 6100 {lab=rowReadON[25]}
N -80 6120 0 6120 {lab=rowReadOFF[25]}
N -80 6580 0 6580 {lab=rowReadON[26]}
N -80 6600 0 6600 {lab=rowReadOFF[26]}
N -80 6620 0 6620 {lab=rowReadON[27]}
N -80 6640 0 6640 {lab=rowReadOFF[27]}
N -80 7100 0 7100 {lab=rowReadON[28]}
N -80 7120 0 7120 {lab=rowReadOFF[28]}
N -80 7140 0 7140 {lab=rowReadON[29]}
N -80 7160 0 7160 {lab=rowReadOFF[29]}
N -80 7620 0 7620 {lab=rowReadON[30]}
N -80 7640 0 7640 {lab=rowReadOFF[30]}
N -80 7660 0 7660 {lab=rowReadON[31]}
N -80 7680 0 7680 {lab=rowReadOFF[31]}
N -80 8140 0 8140 {lab=rowReadON[32]}
N -80 8160 0 8160 {lab=rowReadOFF[32]}
N -80 8180 0 8180 {lab=rowReadON[33]}
N -80 8200 0 8200 {lab=rowReadOFF[33]}
N -80 8660 0 8660 {lab=rowReadON[34]}
N -80 8680 0 8680 {lab=rowReadOFF[34]}
N -80 8700 0 8700 {lab=rowReadON[35]}
N -80 8720 0 8720 {lab=rowReadOFF[35]}
N -80 9180 0 9180 {lab=rowReadON[36]}
N -80 9200 0 9200 {lab=rowReadOFF[36]}
N -80 9220 0 9220 {lab=rowReadON[37]}
N -80 9240 0 9240 {lab=rowReadOFF[37]}
N -80 9700 0 9700 {lab=rowReadON[38]}
N -80 9720 0 9720 {lab=rowReadOFF[38]}
N -80 9740 0 9740 {lab=rowReadON[39]}
N -80 9760 0 9760 {lab=rowReadOFF[39]}
N -80 10220 0 10220 {lab=rowReadON[40]}
N -80 10240 0 10240 {lab=rowReadOFF[40]}
N -80 10260 0 10260 {lab=rowReadON[41]}
N -80 10280 0 10280 {lab=rowReadOFF[41]}
N -80 10740 0 10740 {lab=rowReadON[42]}
N -80 10760 0 10760 {lab=rowReadOFF[42]}
N -80 10780 0 10780 {lab=rowReadON[43]}
N -80 10800 0 10800 {lab=rowReadOFF[43]}
N -80 11260 0 11260 {lab=rowReadON[44]}
N -80 11280 0 11280 {lab=rowReadOFF[44]}
N -80 11300 0 11300 {lab=rowReadON[45]}
N -80 11320 0 11320 {lab=rowReadOFF[45]}
N -80 11780 0 11780 {lab=rowReadON[46]}
N -80 11800 0 11800 {lab=rowReadOFF[46]}
N -80 11820 0 11820 {lab=rowReadON[47]}
N -80 11840 0 11840 {lab=rowReadOFF[47]}
N -80 12300 0 12300 {lab=rowReadON[48]}
N -80 12320 0 12320 {lab=rowReadOFF[48]}
N -80 12340 0 12340 {lab=rowReadON[49]}
N -80 12360 0 12360 {lab=rowReadOFF[49]}
N -80 12820 0 12820 {lab=rowReadON[50]}
N -80 12840 0 12840 {lab=rowReadOFF[50]}
N -80 12860 0 12860 {lab=rowReadON[51]}
N -80 12880 0 12880 {lab=rowReadOFF[51]}
N -80 13340 0 13340 {lab=rowReadON[52]}
N -80 13360 0 13360 {lab=rowReadOFF[52]}
N -80 13380 0 13380 {lab=rowReadON[53]}
N -80 13400 0 13400 {lab=rowReadOFF[53]}
N -80 13860 0 13860 {lab=rowReadON[54]}
N -80 13880 0 13880 {lab=rowReadOFF[54]}
N -80 13900 0 13900 {lab=rowReadON[55]}
N -80 13920 0 13920 {lab=rowReadOFF[55]}
N -80 14380 0 14380 {lab=rowReadON[56]}
N -80 14400 0 14400 {lab=rowReadOFF[56]}
N -80 14420 0 14420 {lab=rowReadON[57]}
N -80 14440 0 14440 {lab=rowReadOFF[57]}
N -80 14900 0 14900 {lab=rowReadON[58]}
N -80 14920 0 14920 {lab=rowReadOFF[58]}
N -80 14940 0 14940 {lab=rowReadON[59]}
N -80 14960 0 14960 {lab=rowReadOFF[59]}
N -80 15420 0 15420 {lab=rowReadON[60]}
N -80 15440 0 15440 {lab=rowReadOFF[60]}
N -80 15460 0 15460 {lab=rowReadON[61]}
N -80 15480 0 15480 {lab=rowReadOFF[61]}
N -80 15940 0 15940 {lab=rowReadON[62]}
N -80 15960 0 15960 {lab=rowReadOFF[62]}
N -80 15980 0 15980 {lab=rowReadON[63]}
N -80 16000 0 16000 {lab=rowReadOFF[63]}
N -80 -660 0 -660 {lab=GND}
N -80 -680 0 -680 {lab=VDD}
N -80 -700 0 -700 {lab=nCHARGE}
N -80 -720 0 -720 {lab=VTHRESH}
N -80 -740 0 -740 {lab=nDETECT}
N -80 -760 0 -760 {lab=DETECT}
N 40 -960 40 -880 {lab=pixRst[0]}
N 280 -960 280 -880 {lab=pixRst[1]}
N 100 -960 100 -880 {lab=voutn[0]}
N 220 -960 220 -880 {lab=voutn[1]}
N 380 -960 380 -880 {lab=pixRst[2]}
N 620 -960 620 -880 {lab=pixRst[3]}
N 440 -960 440 -880 {lab=voutn[2]}
N 560 -960 560 -880 {lab=voutn[3]}
N 720 -960 720 -880 {lab=pixRst[4]}
N 960 -960 960 -880 {lab=pixRst[5]}
N 780 -960 780 -880 {lab=voutn[4]}
N 900 -960 900 -880 {lab=voutn[5]}
N 1060 -960 1060 -880 {lab=pixRst[6]}
N 1300 -960 1300 -880 {lab=pixRst[7]}
N 1120 -960 1120 -880 {lab=voutn[6]}
N 1240 -960 1240 -880 {lab=voutn[7]}
N 1400 -960 1400 -880 {lab=pixRst[8]}
N 1640 -960 1640 -880 {lab=pixRst[9]}
N 1460 -960 1460 -880 {lab=voutn[8]}
N 1580 -960 1580 -880 {lab=voutn[9]}
N 1740 -960 1740 -880 {lab=pixRst[10]}
N 1980 -960 1980 -880 {lab=pixRst[11]}
N 1800 -960 1800 -880 {lab=voutn[10]}
N 1920 -960 1920 -880 {lab=voutn[11]}
N 2080 -960 2080 -880 {lab=pixRst[12]}
N 2320 -960 2320 -880 {lab=pixRst[13]}
N 2140 -960 2140 -880 {lab=voutn[12]}
N 2260 -960 2260 -880 {lab=voutn[13]}
N 2420 -960 2420 -880 {lab=pixRst[14]}
N 2660 -960 2660 -880 {lab=pixRst[15]}
N 2480 -960 2480 -880 {lab=voutn[14]}
N 2600 -960 2600 -880 {lab=voutn[15]}
N 2760 -960 2760 -880 {lab=pixRst[16]}
N 3000 -960 3000 -880 {lab=pixRst[17]}
N 2820 -960 2820 -880 {lab=voutn[16]}
N 2940 -960 2940 -880 {lab=voutn[17]}
N 3100 -960 3100 -880 {lab=pixRst[18]}
N 3340 -960 3340 -880 {lab=pixRst[19]}
N 3160 -960 3160 -880 {lab=voutn[18]}
N 3280 -960 3280 -880 {lab=voutn[19]}
N 3440 -960 3440 -880 {lab=pixRst[20]}
N 3680 -960 3680 -880 {lab=pixRst[21]}
N 3500 -960 3500 -880 {lab=voutn[20]}
N 3620 -960 3620 -880 {lab=voutn[21]}
N 3780 -960 3780 -880 {lab=pixRst[22]}
N 4020 -960 4020 -880 {lab=pixRst[23]}
N 3840 -960 3840 -880 {lab=voutn[22]}
N 3960 -960 3960 -880 {lab=voutn[23]}
N 4120 -960 4120 -880 {lab=pixRst[24]}
N 4360 -960 4360 -880 {lab=pixRst[25]}
N 4180 -960 4180 -880 {lab=voutn[24]}
N 4300 -960 4300 -880 {lab=voutn[25]}
N 4460 -960 4460 -880 {lab=pixRst[26]}
N 4700 -960 4700 -880 {lab=pixRst[27]}
N 4520 -960 4520 -880 {lab=voutn[26]}
N 4640 -960 4640 -880 {lab=voutn[27]}
N 4800 -960 4800 -880 {lab=pixRst[28]}
N 5040 -960 5040 -880 {lab=pixRst[29]}
N 4860 -960 4860 -880 {lab=voutn[28]}
N 4980 -960 4980 -880 {lab=voutn[29]}
N 5140 -960 5140 -880 {lab=pixRst[30]}
N 5380 -960 5380 -880 {lab=pixRst[31]}
N 5200 -960 5200 -880 {lab=voutn[30]}
N 5320 -960 5320 -880 {lab=voutn[31]}
N 5480 -960 5480 -880 {lab=pixRst[32]}
N 5720 -960 5720 -880 {lab=pixRst[33]}
N 5540 -960 5540 -880 {lab=voutn[32]}
N 5660 -960 5660 -880 {lab=voutn[33]}
N 5820 -960 5820 -880 {lab=pixRst[34]}
N 6060 -960 6060 -880 {lab=pixRst[35]}
N 5880 -960 5880 -880 {lab=voutn[34]}
N 6000 -960 6000 -880 {lab=voutn[35]}
N 6160 -960 6160 -880 {lab=pixRst[36]}
N 6400 -960 6400 -880 {lab=pixRst[37]}
N 6220 -960 6220 -880 {lab=voutn[36]}
N 6340 -960 6340 -880 {lab=voutn[37]}
N 6500 -960 6500 -880 {lab=pixRst[38]}
N 6740 -960 6740 -880 {lab=pixRst[39]}
N 6560 -960 6560 -880 {lab=voutn[38]}
N 6680 -960 6680 -880 {lab=voutn[39]}
N 6840 -960 6840 -880 {lab=pixRst[40]}
N 7080 -960 7080 -880 {lab=pixRst[41]}
N 6900 -960 6900 -880 {lab=voutn[40]}
N 7020 -960 7020 -880 {lab=voutn[41]}
N 7180 -960 7180 -880 {lab=pixRst[42]}
N 7420 -960 7420 -880 {lab=pixRst[43]}
N 7240 -960 7240 -880 {lab=voutn[42]}
N 7360 -960 7360 -880 {lab=voutn[43]}
N 7520 -960 7520 -880 {lab=pixRst[44]}
N 7760 -960 7760 -880 {lab=pixRst[45]}
N 7580 -960 7580 -880 {lab=voutn[44]}
N 7700 -960 7700 -880 {lab=voutn[45]}
N 7860 -960 7860 -880 {lab=pixRst[46]}
N 8100 -960 8100 -880 {lab=pixRst[47]}
N 7920 -960 7920 -880 {lab=voutn[46]}
N 8040 -960 8040 -880 {lab=voutn[47]}
N 8200 -960 8200 -880 {lab=pixRst[48]}
N 8440 -960 8440 -880 {lab=pixRst[49]}
N 8260 -960 8260 -880 {lab=voutn[48]}
N 8380 -960 8380 -880 {lab=voutn[49]}
N 8540 -960 8540 -880 {lab=pixRst[50]}
N 8780 -960 8780 -880 {lab=pixRst[51]}
N 8600 -960 8600 -880 {lab=voutn[50]}
N 8720 -960 8720 -880 {lab=voutn[51]}
N 8880 -960 8880 -880 {lab=pixRst[52]}
N 9120 -960 9120 -880 {lab=pixRst[53]}
N 8940 -960 8940 -880 {lab=voutn[52]}
N 9060 -960 9060 -880 {lab=voutn[53]}
N 9220 -960 9220 -880 {lab=pixRst[54]}
N 9460 -960 9460 -880 {lab=pixRst[55]}
N 9280 -960 9280 -880 {lab=voutn[54]}
N 9400 -960 9400 -880 {lab=voutn[55]}
N 9560 -960 9560 -880 {lab=pixRst[56]}
N 9800 -960 9800 -880 {lab=pixRst[57]}
N 9620 -960 9620 -880 {lab=voutn[56]}
N 9740 -960 9740 -880 {lab=voutn[57]}
N 9900 -960 9900 -880 {lab=pixRst[58]}
N 10140 -960 10140 -880 {lab=pixRst[59]}
N 9960 -960 9960 -880 {lab=voutn[58]}
N 10080 -960 10080 -880 {lab=voutn[59]}
N 10240 -960 10240 -880 {lab=pixRst[60]}
N 10480 -960 10480 -880 {lab=pixRst[61]}
N 10300 -960 10300 -880 {lab=voutn[60]}
N 10420 -960 10420 -880 {lab=voutn[61]}
N 10580 -960 10580 -880 {lab=pixRst[62]}
N 10820 -960 10820 -880 {lab=pixRst[63]}
N 10640 -960 10640 -880 {lab=voutn[62]}
N 10760 -960 10760 -880 {lab=voutn[63]}
C {openDVS_pixel2x2.sym} 0 0 0 0 {name=x0}
C {openDVS_pixel2x2.sym} 340 0 0 0 {name=x1}
C {openDVS_pixel2x2.sym} 680 0 0 0 {name=x2}
C {openDVS_pixel2x2.sym} 1020 0 0 0 {name=x3}
C {openDVS_pixel2x2.sym} 1360 0 0 0 {name=x4}
C {openDVS_pixel2x2.sym} 1700 0 0 0 {name=x5}
C {openDVS_pixel2x2.sym} 2040 0 0 0 {name=x6}
C {openDVS_pixel2x2.sym} 2380 0 0 0 {name=x7}
C {openDVS_pixel2x2.sym} 2720 0 0 0 {name=x8}
C {openDVS_pixel2x2.sym} 3060 0 0 0 {name=x9}
C {openDVS_pixel2x2.sym} 3400 0 0 0 {name=x10}
C {openDVS_pixel2x2.sym} 3740 0 0 0 {name=x11}
C {openDVS_pixel2x2.sym} 4080 0 0 0 {name=x12}
C {openDVS_pixel2x2.sym} 4420 0 0 0 {name=x13}
C {openDVS_pixel2x2.sym} 4760 0 0 0 {name=x14}
C {openDVS_pixel2x2.sym} 5100 0 0 0 {name=x15}
C {openDVS_pixel2x2.sym} 5440 0 0 0 {name=x16}
C {openDVS_pixel2x2.sym} 5780 0 0 0 {name=x17}
C {openDVS_pixel2x2.sym} 6120 0 0 0 {name=x18}
C {openDVS_pixel2x2.sym} 6460 0 0 0 {name=x19}
C {openDVS_pixel2x2.sym} 6800 0 0 0 {name=x20}
C {openDVS_pixel2x2.sym} 7140 0 0 0 {name=x21}
C {openDVS_pixel2x2.sym} 7480 0 0 0 {name=x22}
C {openDVS_pixel2x2.sym} 7820 0 0 0 {name=x23}
C {openDVS_pixel2x2.sym} 8160 0 0 0 {name=x24}
C {openDVS_pixel2x2.sym} 8500 0 0 0 {name=x25}
C {openDVS_pixel2x2.sym} 8840 0 0 0 {name=x26}
C {openDVS_pixel2x2.sym} 9180 0 0 0 {name=x27}
C {openDVS_pixel2x2.sym} 9520 0 0 0 {name=x28}
C {openDVS_pixel2x2.sym} 9860 0 0 0 {name=x29}
C {openDVS_pixel2x2.sym} 10200 0 0 0 {name=x30}
C {openDVS_pixel2x2.sym} 10540 0 0 0 {name=x31}
C {openDVS_pixel2x2.sym} 0 520 0 0 {name=x32}
C {openDVS_pixel2x2.sym} 340 520 0 0 {name=x33}
C {openDVS_pixel2x2.sym} 680 520 0 0 {name=x34}
C {openDVS_pixel2x2.sym} 1020 520 0 0 {name=x35}
C {openDVS_pixel2x2.sym} 1360 520 0 0 {name=x36}
C {openDVS_pixel2x2.sym} 1700 520 0 0 {name=x37}
C {openDVS_pixel2x2.sym} 2040 520 0 0 {name=x38}
C {openDVS_pixel2x2.sym} 2380 520 0 0 {name=x39}
C {openDVS_pixel2x2.sym} 2720 520 0 0 {name=x40}
C {openDVS_pixel2x2.sym} 3060 520 0 0 {name=x41}
C {openDVS_pixel2x2.sym} 3400 520 0 0 {name=x42}
C {openDVS_pixel2x2.sym} 3740 520 0 0 {name=x43}
C {openDVS_pixel2x2.sym} 4080 520 0 0 {name=x44}
C {openDVS_pixel2x2.sym} 4420 520 0 0 {name=x45}
C {openDVS_pixel2x2.sym} 4760 520 0 0 {name=x46}
C {openDVS_pixel2x2.sym} 5100 520 0 0 {name=x47}
C {openDVS_pixel2x2.sym} 5440 520 0 0 {name=x48}
C {openDVS_pixel2x2.sym} 5780 520 0 0 {name=x49}
C {openDVS_pixel2x2.sym} 6120 520 0 0 {name=x50}
C {openDVS_pixel2x2.sym} 6460 520 0 0 {name=x51}
C {openDVS_pixel2x2.sym} 6800 520 0 0 {name=x52}
C {openDVS_pixel2x2.sym} 7140 520 0 0 {name=x53}
C {openDVS_pixel2x2.sym} 7480 520 0 0 {name=x54}
C {openDVS_pixel2x2.sym} 7820 520 0 0 {name=x55}
C {openDVS_pixel2x2.sym} 8160 520 0 0 {name=x56}
C {openDVS_pixel2x2.sym} 8500 520 0 0 {name=x57}
C {openDVS_pixel2x2.sym} 8840 520 0 0 {name=x58}
C {openDVS_pixel2x2.sym} 9180 520 0 0 {name=x59}
C {openDVS_pixel2x2.sym} 9520 520 0 0 {name=x60}
C {openDVS_pixel2x2.sym} 9860 520 0 0 {name=x61}
C {openDVS_pixel2x2.sym} 10200 520 0 0 {name=x62}
C {openDVS_pixel2x2.sym} 10540 520 0 0 {name=x63}
C {openDVS_pixel2x2.sym} 0 1040 0 0 {name=x64}
C {openDVS_pixel2x2.sym} 340 1040 0 0 {name=x65}
C {openDVS_pixel2x2.sym} 680 1040 0 0 {name=x66}
C {openDVS_pixel2x2.sym} 1020 1040 0 0 {name=x67}
C {openDVS_pixel2x2.sym} 1360 1040 0 0 {name=x68}
C {openDVS_pixel2x2.sym} 1700 1040 0 0 {name=x69}
C {openDVS_pixel2x2.sym} 2040 1040 0 0 {name=x70}
C {openDVS_pixel2x2.sym} 2380 1040 0 0 {name=x71}
C {openDVS_pixel2x2.sym} 2720 1040 0 0 {name=x72}
C {openDVS_pixel2x2.sym} 3060 1040 0 0 {name=x73}
C {openDVS_pixel2x2.sym} 3400 1040 0 0 {name=x74}
C {openDVS_pixel2x2.sym} 3740 1040 0 0 {name=x75}
C {openDVS_pixel2x2.sym} 4080 1040 0 0 {name=x76}
C {openDVS_pixel2x2.sym} 4420 1040 0 0 {name=x77}
C {openDVS_pixel2x2.sym} 4760 1040 0 0 {name=x78}
C {openDVS_pixel2x2.sym} 5100 1040 0 0 {name=x79}
C {openDVS_pixel2x2.sym} 5440 1040 0 0 {name=x80}
C {openDVS_pixel2x2.sym} 5780 1040 0 0 {name=x81}
C {openDVS_pixel2x2.sym} 6120 1040 0 0 {name=x82}
C {openDVS_pixel2x2.sym} 6460 1040 0 0 {name=x83}
C {openDVS_pixel2x2.sym} 6800 1040 0 0 {name=x84}
C {openDVS_pixel2x2.sym} 7140 1040 0 0 {name=x85}
C {openDVS_pixel2x2.sym} 7480 1040 0 0 {name=x86}
C {openDVS_pixel2x2.sym} 7820 1040 0 0 {name=x87}
C {openDVS_pixel2x2.sym} 8160 1040 0 0 {name=x88}
C {openDVS_pixel2x2.sym} 8500 1040 0 0 {name=x89}
C {openDVS_pixel2x2.sym} 8840 1040 0 0 {name=x90}
C {openDVS_pixel2x2.sym} 9180 1040 0 0 {name=x91}
C {openDVS_pixel2x2.sym} 9520 1040 0 0 {name=x92}
C {openDVS_pixel2x2.sym} 9860 1040 0 0 {name=x93}
C {openDVS_pixel2x2.sym} 10200 1040 0 0 {name=x94}
C {openDVS_pixel2x2.sym} 10540 1040 0 0 {name=x95}
C {openDVS_pixel2x2.sym} 0 1560 0 0 {name=x96}
C {openDVS_pixel2x2.sym} 340 1560 0 0 {name=x97}
C {openDVS_pixel2x2.sym} 680 1560 0 0 {name=x98}
C {openDVS_pixel2x2.sym} 1020 1560 0 0 {name=x99}
C {openDVS_pixel2x2.sym} 1360 1560 0 0 {name=x100}
C {openDVS_pixel2x2.sym} 1700 1560 0 0 {name=x101}
C {openDVS_pixel2x2.sym} 2040 1560 0 0 {name=x102}
C {openDVS_pixel2x2.sym} 2380 1560 0 0 {name=x103}
C {openDVS_pixel2x2.sym} 2720 1560 0 0 {name=x104}
C {openDVS_pixel2x2.sym} 3060 1560 0 0 {name=x105}
C {openDVS_pixel2x2.sym} 3400 1560 0 0 {name=x106}
C {openDVS_pixel2x2.sym} 3740 1560 0 0 {name=x107}
C {openDVS_pixel2x2.sym} 4080 1560 0 0 {name=x108}
C {openDVS_pixel2x2.sym} 4420 1560 0 0 {name=x109}
C {openDVS_pixel2x2.sym} 4760 1560 0 0 {name=x110}
C {openDVS_pixel2x2.sym} 5100 1560 0 0 {name=x111}
C {openDVS_pixel2x2.sym} 5440 1560 0 0 {name=x112}
C {openDVS_pixel2x2.sym} 5780 1560 0 0 {name=x113}
C {openDVS_pixel2x2.sym} 6120 1560 0 0 {name=x114}
C {openDVS_pixel2x2.sym} 6460 1560 0 0 {name=x115}
C {openDVS_pixel2x2.sym} 6800 1560 0 0 {name=x116}
C {openDVS_pixel2x2.sym} 7140 1560 0 0 {name=x117}
C {openDVS_pixel2x2.sym} 7480 1560 0 0 {name=x118}
C {openDVS_pixel2x2.sym} 7820 1560 0 0 {name=x119}
C {openDVS_pixel2x2.sym} 8160 1560 0 0 {name=x120}
C {openDVS_pixel2x2.sym} 8500 1560 0 0 {name=x121}
C {openDVS_pixel2x2.sym} 8840 1560 0 0 {name=x122}
C {openDVS_pixel2x2.sym} 9180 1560 0 0 {name=x123}
C {openDVS_pixel2x2.sym} 9520 1560 0 0 {name=x124}
C {openDVS_pixel2x2.sym} 9860 1560 0 0 {name=x125}
C {openDVS_pixel2x2.sym} 10200 1560 0 0 {name=x126}
C {openDVS_pixel2x2.sym} 10540 1560 0 0 {name=x127}
C {openDVS_pixel2x2.sym} 0 2080 0 0 {name=x128}
C {openDVS_pixel2x2.sym} 340 2080 0 0 {name=x129}
C {openDVS_pixel2x2.sym} 680 2080 0 0 {name=x130}
C {openDVS_pixel2x2.sym} 1020 2080 0 0 {name=x131}
C {openDVS_pixel2x2.sym} 1360 2080 0 0 {name=x132}
C {openDVS_pixel2x2.sym} 1700 2080 0 0 {name=x133}
C {openDVS_pixel2x2.sym} 2040 2080 0 0 {name=x134}
C {openDVS_pixel2x2.sym} 2380 2080 0 0 {name=x135}
C {openDVS_pixel2x2.sym} 2720 2080 0 0 {name=x136}
C {openDVS_pixel2x2.sym} 3060 2080 0 0 {name=x137}
C {openDVS_pixel2x2.sym} 3400 2080 0 0 {name=x138}
C {openDVS_pixel2x2.sym} 3740 2080 0 0 {name=x139}
C {openDVS_pixel2x2.sym} 4080 2080 0 0 {name=x140}
C {openDVS_pixel2x2.sym} 4420 2080 0 0 {name=x141}
C {openDVS_pixel2x2.sym} 4760 2080 0 0 {name=x142}
C {openDVS_pixel2x2.sym} 5100 2080 0 0 {name=x143}
C {openDVS_pixel2x2.sym} 5440 2080 0 0 {name=x144}
C {openDVS_pixel2x2.sym} 5780 2080 0 0 {name=x145}
C {openDVS_pixel2x2.sym} 6120 2080 0 0 {name=x146}
C {openDVS_pixel2x2.sym} 6460 2080 0 0 {name=x147}
C {openDVS_pixel2x2.sym} 6800 2080 0 0 {name=x148}
C {openDVS_pixel2x2.sym} 7140 2080 0 0 {name=x149}
C {openDVS_pixel2x2.sym} 7480 2080 0 0 {name=x150}
C {openDVS_pixel2x2.sym} 7820 2080 0 0 {name=x151}
C {openDVS_pixel2x2.sym} 8160 2080 0 0 {name=x152}
C {openDVS_pixel2x2.sym} 8500 2080 0 0 {name=x153}
C {openDVS_pixel2x2.sym} 8840 2080 0 0 {name=x154}
C {openDVS_pixel2x2.sym} 9180 2080 0 0 {name=x155}
C {openDVS_pixel2x2.sym} 9520 2080 0 0 {name=x156}
C {openDVS_pixel2x2.sym} 9860 2080 0 0 {name=x157}
C {openDVS_pixel2x2.sym} 10200 2080 0 0 {name=x158}
C {openDVS_pixel2x2.sym} 10540 2080 0 0 {name=x159}
C {openDVS_pixel2x2.sym} 0 2600 0 0 {name=x160}
C {openDVS_pixel2x2.sym} 340 2600 0 0 {name=x161}
C {openDVS_pixel2x2.sym} 680 2600 0 0 {name=x162}
C {openDVS_pixel2x2.sym} 1020 2600 0 0 {name=x163}
C {openDVS_pixel2x2.sym} 1360 2600 0 0 {name=x164}
C {openDVS_pixel2x2.sym} 1700 2600 0 0 {name=x165}
C {openDVS_pixel2x2.sym} 2040 2600 0 0 {name=x166}
C {openDVS_pixel2x2.sym} 2380 2600 0 0 {name=x167}
C {openDVS_pixel2x2.sym} 2720 2600 0 0 {name=x168}
C {openDVS_pixel2x2.sym} 3060 2600 0 0 {name=x169}
C {openDVS_pixel2x2.sym} 3400 2600 0 0 {name=x170}
C {openDVS_pixel2x2.sym} 3740 2600 0 0 {name=x171}
C {openDVS_pixel2x2.sym} 4080 2600 0 0 {name=x172}
C {openDVS_pixel2x2.sym} 4420 2600 0 0 {name=x173}
C {openDVS_pixel2x2.sym} 4760 2600 0 0 {name=x174}
C {openDVS_pixel2x2.sym} 5100 2600 0 0 {name=x175}
C {openDVS_pixel2x2.sym} 5440 2600 0 0 {name=x176}
C {openDVS_pixel2x2.sym} 5780 2600 0 0 {name=x177}
C {openDVS_pixel2x2.sym} 6120 2600 0 0 {name=x178}
C {openDVS_pixel2x2.sym} 6460 2600 0 0 {name=x179}
C {openDVS_pixel2x2.sym} 6800 2600 0 0 {name=x180}
C {openDVS_pixel2x2.sym} 7140 2600 0 0 {name=x181}
C {openDVS_pixel2x2.sym} 7480 2600 0 0 {name=x182}
C {openDVS_pixel2x2.sym} 7820 2600 0 0 {name=x183}
C {openDVS_pixel2x2.sym} 8160 2600 0 0 {name=x184}
C {openDVS_pixel2x2.sym} 8500 2600 0 0 {name=x185}
C {openDVS_pixel2x2.sym} 8840 2600 0 0 {name=x186}
C {openDVS_pixel2x2.sym} 9180 2600 0 0 {name=x187}
C {openDVS_pixel2x2.sym} 9520 2600 0 0 {name=x188}
C {openDVS_pixel2x2.sym} 9860 2600 0 0 {name=x189}
C {openDVS_pixel2x2.sym} 10200 2600 0 0 {name=x190}
C {openDVS_pixel2x2.sym} 10540 2600 0 0 {name=x191}
C {openDVS_pixel2x2.sym} 0 3120 0 0 {name=x192}
C {openDVS_pixel2x2.sym} 340 3120 0 0 {name=x193}
C {openDVS_pixel2x2.sym} 680 3120 0 0 {name=x194}
C {openDVS_pixel2x2.sym} 1020 3120 0 0 {name=x195}
C {openDVS_pixel2x2.sym} 1360 3120 0 0 {name=x196}
C {openDVS_pixel2x2.sym} 1700 3120 0 0 {name=x197}
C {openDVS_pixel2x2.sym} 2040 3120 0 0 {name=x198}
C {openDVS_pixel2x2.sym} 2380 3120 0 0 {name=x199}
C {openDVS_pixel2x2.sym} 2720 3120 0 0 {name=x200}
C {openDVS_pixel2x2.sym} 3060 3120 0 0 {name=x201}
C {openDVS_pixel2x2.sym} 3400 3120 0 0 {name=x202}
C {openDVS_pixel2x2.sym} 3740 3120 0 0 {name=x203}
C {openDVS_pixel2x2.sym} 4080 3120 0 0 {name=x204}
C {openDVS_pixel2x2.sym} 4420 3120 0 0 {name=x205}
C {openDVS_pixel2x2.sym} 4760 3120 0 0 {name=x206}
C {openDVS_pixel2x2.sym} 5100 3120 0 0 {name=x207}
C {openDVS_pixel2x2.sym} 5440 3120 0 0 {name=x208}
C {openDVS_pixel2x2.sym} 5780 3120 0 0 {name=x209}
C {openDVS_pixel2x2.sym} 6120 3120 0 0 {name=x210}
C {openDVS_pixel2x2.sym} 6460 3120 0 0 {name=x211}
C {openDVS_pixel2x2.sym} 6800 3120 0 0 {name=x212}
C {openDVS_pixel2x2.sym} 7140 3120 0 0 {name=x213}
C {openDVS_pixel2x2.sym} 7480 3120 0 0 {name=x214}
C {openDVS_pixel2x2.sym} 7820 3120 0 0 {name=x215}
C {openDVS_pixel2x2.sym} 8160 3120 0 0 {name=x216}
C {openDVS_pixel2x2.sym} 8500 3120 0 0 {name=x217}
C {openDVS_pixel2x2.sym} 8840 3120 0 0 {name=x218}
C {openDVS_pixel2x2.sym} 9180 3120 0 0 {name=x219}
C {openDVS_pixel2x2.sym} 9520 3120 0 0 {name=x220}
C {openDVS_pixel2x2.sym} 9860 3120 0 0 {name=x221}
C {openDVS_pixel2x2.sym} 10200 3120 0 0 {name=x222}
C {openDVS_pixel2x2.sym} 10540 3120 0 0 {name=x223}
C {openDVS_pixel2x2.sym} 0 3640 0 0 {name=x224}
C {openDVS_pixel2x2.sym} 340 3640 0 0 {name=x225}
C {openDVS_pixel2x2.sym} 680 3640 0 0 {name=x226}
C {openDVS_pixel2x2.sym} 1020 3640 0 0 {name=x227}
C {openDVS_pixel2x2.sym} 1360 3640 0 0 {name=x228}
C {openDVS_pixel2x2.sym} 1700 3640 0 0 {name=x229}
C {openDVS_pixel2x2.sym} 2040 3640 0 0 {name=x230}
C {openDVS_pixel2x2.sym} 2380 3640 0 0 {name=x231}
C {openDVS_pixel2x2.sym} 2720 3640 0 0 {name=x232}
C {openDVS_pixel2x2.sym} 3060 3640 0 0 {name=x233}
C {openDVS_pixel2x2.sym} 3400 3640 0 0 {name=x234}
C {openDVS_pixel2x2.sym} 3740 3640 0 0 {name=x235}
C {openDVS_pixel2x2.sym} 4080 3640 0 0 {name=x236}
C {openDVS_pixel2x2.sym} 4420 3640 0 0 {name=x237}
C {openDVS_pixel2x2.sym} 4760 3640 0 0 {name=x238}
C {openDVS_pixel2x2.sym} 5100 3640 0 0 {name=x239}
C {openDVS_pixel2x2.sym} 5440 3640 0 0 {name=x240}
C {openDVS_pixel2x2.sym} 5780 3640 0 0 {name=x241}
C {openDVS_pixel2x2.sym} 6120 3640 0 0 {name=x242}
C {openDVS_pixel2x2.sym} 6460 3640 0 0 {name=x243}
C {openDVS_pixel2x2.sym} 6800 3640 0 0 {name=x244}
C {openDVS_pixel2x2.sym} 7140 3640 0 0 {name=x245}
C {openDVS_pixel2x2.sym} 7480 3640 0 0 {name=x246}
C {openDVS_pixel2x2.sym} 7820 3640 0 0 {name=x247}
C {openDVS_pixel2x2.sym} 8160 3640 0 0 {name=x248}
C {openDVS_pixel2x2.sym} 8500 3640 0 0 {name=x249}
C {openDVS_pixel2x2.sym} 8840 3640 0 0 {name=x250}
C {openDVS_pixel2x2.sym} 9180 3640 0 0 {name=x251}
C {openDVS_pixel2x2.sym} 9520 3640 0 0 {name=x252}
C {openDVS_pixel2x2.sym} 9860 3640 0 0 {name=x253}
C {openDVS_pixel2x2.sym} 10200 3640 0 0 {name=x254}
C {openDVS_pixel2x2.sym} 10540 3640 0 0 {name=x255}
C {openDVS_pixel2x2.sym} 0 4160 0 0 {name=x256}
C {openDVS_pixel2x2.sym} 340 4160 0 0 {name=x257}
C {openDVS_pixel2x2.sym} 680 4160 0 0 {name=x258}
C {openDVS_pixel2x2.sym} 1020 4160 0 0 {name=x259}
C {openDVS_pixel2x2.sym} 1360 4160 0 0 {name=x260}
C {openDVS_pixel2x2.sym} 1700 4160 0 0 {name=x261}
C {openDVS_pixel2x2.sym} 2040 4160 0 0 {name=x262}
C {openDVS_pixel2x2.sym} 2380 4160 0 0 {name=x263}
C {openDVS_pixel2x2.sym} 2720 4160 0 0 {name=x264}
C {openDVS_pixel2x2.sym} 3060 4160 0 0 {name=x265}
C {openDVS_pixel2x2.sym} 3400 4160 0 0 {name=x266}
C {openDVS_pixel2x2.sym} 3740 4160 0 0 {name=x267}
C {openDVS_pixel2x2.sym} 4080 4160 0 0 {name=x268}
C {openDVS_pixel2x2.sym} 4420 4160 0 0 {name=x269}
C {openDVS_pixel2x2.sym} 4760 4160 0 0 {name=x270}
C {openDVS_pixel2x2.sym} 5100 4160 0 0 {name=x271}
C {openDVS_pixel2x2.sym} 5440 4160 0 0 {name=x272}
C {openDVS_pixel2x2.sym} 5780 4160 0 0 {name=x273}
C {openDVS_pixel2x2.sym} 6120 4160 0 0 {name=x274}
C {openDVS_pixel2x2.sym} 6460 4160 0 0 {name=x275}
C {openDVS_pixel2x2.sym} 6800 4160 0 0 {name=x276}
C {openDVS_pixel2x2.sym} 7140 4160 0 0 {name=x277}
C {openDVS_pixel2x2.sym} 7480 4160 0 0 {name=x278}
C {openDVS_pixel2x2.sym} 7820 4160 0 0 {name=x279}
C {openDVS_pixel2x2.sym} 8160 4160 0 0 {name=x280}
C {openDVS_pixel2x2.sym} 8500 4160 0 0 {name=x281}
C {openDVS_pixel2x2.sym} 8840 4160 0 0 {name=x282}
C {openDVS_pixel2x2.sym} 9180 4160 0 0 {name=x283}
C {openDVS_pixel2x2.sym} 9520 4160 0 0 {name=x284}
C {openDVS_pixel2x2.sym} 9860 4160 0 0 {name=x285}
C {openDVS_pixel2x2.sym} 10200 4160 0 0 {name=x286}
C {openDVS_pixel2x2.sym} 10540 4160 0 0 {name=x287}
C {openDVS_pixel2x2.sym} 0 4680 0 0 {name=x288}
C {openDVS_pixel2x2.sym} 340 4680 0 0 {name=x289}
C {openDVS_pixel2x2.sym} 680 4680 0 0 {name=x290}
C {openDVS_pixel2x2.sym} 1020 4680 0 0 {name=x291}
C {openDVS_pixel2x2.sym} 1360 4680 0 0 {name=x292}
C {openDVS_pixel2x2.sym} 1700 4680 0 0 {name=x293}
C {openDVS_pixel2x2.sym} 2040 4680 0 0 {name=x294}
C {openDVS_pixel2x2.sym} 2380 4680 0 0 {name=x295}
C {openDVS_pixel2x2.sym} 2720 4680 0 0 {name=x296}
C {openDVS_pixel2x2.sym} 3060 4680 0 0 {name=x297}
C {openDVS_pixel2x2.sym} 3400 4680 0 0 {name=x298}
C {openDVS_pixel2x2.sym} 3740 4680 0 0 {name=x299}
C {openDVS_pixel2x2.sym} 4080 4680 0 0 {name=x300}
C {openDVS_pixel2x2.sym} 4420 4680 0 0 {name=x301}
C {openDVS_pixel2x2.sym} 4760 4680 0 0 {name=x302}
C {openDVS_pixel2x2.sym} 5100 4680 0 0 {name=x303}
C {openDVS_pixel2x2.sym} 5440 4680 0 0 {name=x304}
C {openDVS_pixel2x2.sym} 5780 4680 0 0 {name=x305}
C {openDVS_pixel2x2.sym} 6120 4680 0 0 {name=x306}
C {openDVS_pixel2x2.sym} 6460 4680 0 0 {name=x307}
C {openDVS_pixel2x2.sym} 6800 4680 0 0 {name=x308}
C {openDVS_pixel2x2.sym} 7140 4680 0 0 {name=x309}
C {openDVS_pixel2x2.sym} 7480 4680 0 0 {name=x310}
C {openDVS_pixel2x2.sym} 7820 4680 0 0 {name=x311}
C {openDVS_pixel2x2.sym} 8160 4680 0 0 {name=x312}
C {openDVS_pixel2x2.sym} 8500 4680 0 0 {name=x313}
C {openDVS_pixel2x2.sym} 8840 4680 0 0 {name=x314}
C {openDVS_pixel2x2.sym} 9180 4680 0 0 {name=x315}
C {openDVS_pixel2x2.sym} 9520 4680 0 0 {name=x316}
C {openDVS_pixel2x2.sym} 9860 4680 0 0 {name=x317}
C {openDVS_pixel2x2.sym} 10200 4680 0 0 {name=x318}
C {openDVS_pixel2x2.sym} 10540 4680 0 0 {name=x319}
C {openDVS_pixel2x2.sym} 0 5200 0 0 {name=x320}
C {openDVS_pixel2x2.sym} 340 5200 0 0 {name=x321}
C {openDVS_pixel2x2.sym} 680 5200 0 0 {name=x322}
C {openDVS_pixel2x2.sym} 1020 5200 0 0 {name=x323}
C {openDVS_pixel2x2.sym} 1360 5200 0 0 {name=x324}
C {openDVS_pixel2x2.sym} 1700 5200 0 0 {name=x325}
C {openDVS_pixel2x2.sym} 2040 5200 0 0 {name=x326}
C {openDVS_pixel2x2.sym} 2380 5200 0 0 {name=x327}
C {openDVS_pixel2x2.sym} 2720 5200 0 0 {name=x328}
C {openDVS_pixel2x2.sym} 3060 5200 0 0 {name=x329}
C {openDVS_pixel2x2.sym} 3400 5200 0 0 {name=x330}
C {openDVS_pixel2x2.sym} 3740 5200 0 0 {name=x331}
C {openDVS_pixel2x2.sym} 4080 5200 0 0 {name=x332}
C {openDVS_pixel2x2.sym} 4420 5200 0 0 {name=x333}
C {openDVS_pixel2x2.sym} 4760 5200 0 0 {name=x334}
C {openDVS_pixel2x2.sym} 5100 5200 0 0 {name=x335}
C {openDVS_pixel2x2.sym} 5440 5200 0 0 {name=x336}
C {openDVS_pixel2x2.sym} 5780 5200 0 0 {name=x337}
C {openDVS_pixel2x2.sym} 6120 5200 0 0 {name=x338}
C {openDVS_pixel2x2.sym} 6460 5200 0 0 {name=x339}
C {openDVS_pixel2x2.sym} 6800 5200 0 0 {name=x340}
C {openDVS_pixel2x2.sym} 7140 5200 0 0 {name=x341}
C {openDVS_pixel2x2.sym} 7480 5200 0 0 {name=x342}
C {openDVS_pixel2x2.sym} 7820 5200 0 0 {name=x343}
C {openDVS_pixel2x2.sym} 8160 5200 0 0 {name=x344}
C {openDVS_pixel2x2.sym} 8500 5200 0 0 {name=x345}
C {openDVS_pixel2x2.sym} 8840 5200 0 0 {name=x346}
C {openDVS_pixel2x2.sym} 9180 5200 0 0 {name=x347}
C {openDVS_pixel2x2.sym} 9520 5200 0 0 {name=x348}
C {openDVS_pixel2x2.sym} 9860 5200 0 0 {name=x349}
C {openDVS_pixel2x2.sym} 10200 5200 0 0 {name=x350}
C {openDVS_pixel2x2.sym} 10540 5200 0 0 {name=x351}
C {openDVS_pixel2x2.sym} 0 5720 0 0 {name=x352}
C {openDVS_pixel2x2.sym} 340 5720 0 0 {name=x353}
C {openDVS_pixel2x2.sym} 680 5720 0 0 {name=x354}
C {openDVS_pixel2x2.sym} 1020 5720 0 0 {name=x355}
C {openDVS_pixel2x2.sym} 1360 5720 0 0 {name=x356}
C {openDVS_pixel2x2.sym} 1700 5720 0 0 {name=x357}
C {openDVS_pixel2x2.sym} 2040 5720 0 0 {name=x358}
C {openDVS_pixel2x2.sym} 2380 5720 0 0 {name=x359}
C {openDVS_pixel2x2.sym} 2720 5720 0 0 {name=x360}
C {openDVS_pixel2x2.sym} 3060 5720 0 0 {name=x361}
C {openDVS_pixel2x2.sym} 3400 5720 0 0 {name=x362}
C {openDVS_pixel2x2.sym} 3740 5720 0 0 {name=x363}
C {openDVS_pixel2x2.sym} 4080 5720 0 0 {name=x364}
C {openDVS_pixel2x2.sym} 4420 5720 0 0 {name=x365}
C {openDVS_pixel2x2.sym} 4760 5720 0 0 {name=x366}
C {openDVS_pixel2x2.sym} 5100 5720 0 0 {name=x367}
C {openDVS_pixel2x2.sym} 5440 5720 0 0 {name=x368}
C {openDVS_pixel2x2.sym} 5780 5720 0 0 {name=x369}
C {openDVS_pixel2x2.sym} 6120 5720 0 0 {name=x370}
C {openDVS_pixel2x2.sym} 6460 5720 0 0 {name=x371}
C {openDVS_pixel2x2.sym} 6800 5720 0 0 {name=x372}
C {openDVS_pixel2x2.sym} 7140 5720 0 0 {name=x373}
C {openDVS_pixel2x2.sym} 7480 5720 0 0 {name=x374}
C {openDVS_pixel2x2.sym} 7820 5720 0 0 {name=x375}
C {openDVS_pixel2x2.sym} 8160 5720 0 0 {name=x376}
C {openDVS_pixel2x2.sym} 8500 5720 0 0 {name=x377}
C {openDVS_pixel2x2.sym} 8840 5720 0 0 {name=x378}
C {openDVS_pixel2x2.sym} 9180 5720 0 0 {name=x379}
C {openDVS_pixel2x2.sym} 9520 5720 0 0 {name=x380}
C {openDVS_pixel2x2.sym} 9860 5720 0 0 {name=x381}
C {openDVS_pixel2x2.sym} 10200 5720 0 0 {name=x382}
C {openDVS_pixel2x2.sym} 10540 5720 0 0 {name=x383}
C {openDVS_pixel2x2.sym} 0 6240 0 0 {name=x384}
C {openDVS_pixel2x2.sym} 340 6240 0 0 {name=x385}
C {openDVS_pixel2x2.sym} 680 6240 0 0 {name=x386}
C {openDVS_pixel2x2.sym} 1020 6240 0 0 {name=x387}
C {openDVS_pixel2x2.sym} 1360 6240 0 0 {name=x388}
C {openDVS_pixel2x2.sym} 1700 6240 0 0 {name=x389}
C {openDVS_pixel2x2.sym} 2040 6240 0 0 {name=x390}
C {openDVS_pixel2x2.sym} 2380 6240 0 0 {name=x391}
C {openDVS_pixel2x2.sym} 2720 6240 0 0 {name=x392}
C {openDVS_pixel2x2.sym} 3060 6240 0 0 {name=x393}
C {openDVS_pixel2x2.sym} 3400 6240 0 0 {name=x394}
C {openDVS_pixel2x2.sym} 3740 6240 0 0 {name=x395}
C {openDVS_pixel2x2.sym} 4080 6240 0 0 {name=x396}
C {openDVS_pixel2x2.sym} 4420 6240 0 0 {name=x397}
C {openDVS_pixel2x2.sym} 4760 6240 0 0 {name=x398}
C {openDVS_pixel2x2.sym} 5100 6240 0 0 {name=x399}
C {openDVS_pixel2x2.sym} 5440 6240 0 0 {name=x400}
C {openDVS_pixel2x2.sym} 5780 6240 0 0 {name=x401}
C {openDVS_pixel2x2.sym} 6120 6240 0 0 {name=x402}
C {openDVS_pixel2x2.sym} 6460 6240 0 0 {name=x403}
C {openDVS_pixel2x2.sym} 6800 6240 0 0 {name=x404}
C {openDVS_pixel2x2.sym} 7140 6240 0 0 {name=x405}
C {openDVS_pixel2x2.sym} 7480 6240 0 0 {name=x406}
C {openDVS_pixel2x2.sym} 7820 6240 0 0 {name=x407}
C {openDVS_pixel2x2.sym} 8160 6240 0 0 {name=x408}
C {openDVS_pixel2x2.sym} 8500 6240 0 0 {name=x409}
C {openDVS_pixel2x2.sym} 8840 6240 0 0 {name=x410}
C {openDVS_pixel2x2.sym} 9180 6240 0 0 {name=x411}
C {openDVS_pixel2x2.sym} 9520 6240 0 0 {name=x412}
C {openDVS_pixel2x2.sym} 9860 6240 0 0 {name=x413}
C {openDVS_pixel2x2.sym} 10200 6240 0 0 {name=x414}
C {openDVS_pixel2x2.sym} 10540 6240 0 0 {name=x415}
C {openDVS_pixel2x2.sym} 0 6760 0 0 {name=x416}
C {openDVS_pixel2x2.sym} 340 6760 0 0 {name=x417}
C {openDVS_pixel2x2.sym} 680 6760 0 0 {name=x418}
C {openDVS_pixel2x2.sym} 1020 6760 0 0 {name=x419}
C {openDVS_pixel2x2.sym} 1360 6760 0 0 {name=x420}
C {openDVS_pixel2x2.sym} 1700 6760 0 0 {name=x421}
C {openDVS_pixel2x2.sym} 2040 6760 0 0 {name=x422}
C {openDVS_pixel2x2.sym} 2380 6760 0 0 {name=x423}
C {openDVS_pixel2x2.sym} 2720 6760 0 0 {name=x424}
C {openDVS_pixel2x2.sym} 3060 6760 0 0 {name=x425}
C {openDVS_pixel2x2.sym} 3400 6760 0 0 {name=x426}
C {openDVS_pixel2x2.sym} 3740 6760 0 0 {name=x427}
C {openDVS_pixel2x2.sym} 4080 6760 0 0 {name=x428}
C {openDVS_pixel2x2.sym} 4420 6760 0 0 {name=x429}
C {openDVS_pixel2x2.sym} 4760 6760 0 0 {name=x430}
C {openDVS_pixel2x2.sym} 5100 6760 0 0 {name=x431}
C {openDVS_pixel2x2.sym} 5440 6760 0 0 {name=x432}
C {openDVS_pixel2x2.sym} 5780 6760 0 0 {name=x433}
C {openDVS_pixel2x2.sym} 6120 6760 0 0 {name=x434}
C {openDVS_pixel2x2.sym} 6460 6760 0 0 {name=x435}
C {openDVS_pixel2x2.sym} 6800 6760 0 0 {name=x436}
C {openDVS_pixel2x2.sym} 7140 6760 0 0 {name=x437}
C {openDVS_pixel2x2.sym} 7480 6760 0 0 {name=x438}
C {openDVS_pixel2x2.sym} 7820 6760 0 0 {name=x439}
C {openDVS_pixel2x2.sym} 8160 6760 0 0 {name=x440}
C {openDVS_pixel2x2.sym} 8500 6760 0 0 {name=x441}
C {openDVS_pixel2x2.sym} 8840 6760 0 0 {name=x442}
C {openDVS_pixel2x2.sym} 9180 6760 0 0 {name=x443}
C {openDVS_pixel2x2.sym} 9520 6760 0 0 {name=x444}
C {openDVS_pixel2x2.sym} 9860 6760 0 0 {name=x445}
C {openDVS_pixel2x2.sym} 10200 6760 0 0 {name=x446}
C {openDVS_pixel2x2.sym} 10540 6760 0 0 {name=x447}
C {openDVS_pixel2x2.sym} 0 7280 0 0 {name=x448}
C {openDVS_pixel2x2.sym} 340 7280 0 0 {name=x449}
C {openDVS_pixel2x2.sym} 680 7280 0 0 {name=x450}
C {openDVS_pixel2x2.sym} 1020 7280 0 0 {name=x451}
C {openDVS_pixel2x2.sym} 1360 7280 0 0 {name=x452}
C {openDVS_pixel2x2.sym} 1700 7280 0 0 {name=x453}
C {openDVS_pixel2x2.sym} 2040 7280 0 0 {name=x454}
C {openDVS_pixel2x2.sym} 2380 7280 0 0 {name=x455}
C {openDVS_pixel2x2.sym} 2720 7280 0 0 {name=x456}
C {openDVS_pixel2x2.sym} 3060 7280 0 0 {name=x457}
C {openDVS_pixel2x2.sym} 3400 7280 0 0 {name=x458}
C {openDVS_pixel2x2.sym} 3740 7280 0 0 {name=x459}
C {openDVS_pixel2x2.sym} 4080 7280 0 0 {name=x460}
C {openDVS_pixel2x2.sym} 4420 7280 0 0 {name=x461}
C {openDVS_pixel2x2.sym} 4760 7280 0 0 {name=x462}
C {openDVS_pixel2x2.sym} 5100 7280 0 0 {name=x463}
C {openDVS_pixel2x2.sym} 5440 7280 0 0 {name=x464}
C {openDVS_pixel2x2.sym} 5780 7280 0 0 {name=x465}
C {openDVS_pixel2x2.sym} 6120 7280 0 0 {name=x466}
C {openDVS_pixel2x2.sym} 6460 7280 0 0 {name=x467}
C {openDVS_pixel2x2.sym} 6800 7280 0 0 {name=x468}
C {openDVS_pixel2x2.sym} 7140 7280 0 0 {name=x469}
C {openDVS_pixel2x2.sym} 7480 7280 0 0 {name=x470}
C {openDVS_pixel2x2.sym} 7820 7280 0 0 {name=x471}
C {openDVS_pixel2x2.sym} 8160 7280 0 0 {name=x472}
C {openDVS_pixel2x2.sym} 8500 7280 0 0 {name=x473}
C {openDVS_pixel2x2.sym} 8840 7280 0 0 {name=x474}
C {openDVS_pixel2x2.sym} 9180 7280 0 0 {name=x475}
C {openDVS_pixel2x2.sym} 9520 7280 0 0 {name=x476}
C {openDVS_pixel2x2.sym} 9860 7280 0 0 {name=x477}
C {openDVS_pixel2x2.sym} 10200 7280 0 0 {name=x478}
C {openDVS_pixel2x2.sym} 10540 7280 0 0 {name=x479}
C {openDVS_pixel2x2.sym} 0 7800 0 0 {name=x480}
C {openDVS_pixel2x2.sym} 340 7800 0 0 {name=x481}
C {openDVS_pixel2x2.sym} 680 7800 0 0 {name=x482}
C {openDVS_pixel2x2.sym} 1020 7800 0 0 {name=x483}
C {openDVS_pixel2x2.sym} 1360 7800 0 0 {name=x484}
C {openDVS_pixel2x2.sym} 1700 7800 0 0 {name=x485}
C {openDVS_pixel2x2.sym} 2040 7800 0 0 {name=x486}
C {openDVS_pixel2x2.sym} 2380 7800 0 0 {name=x487}
C {openDVS_pixel2x2.sym} 2720 7800 0 0 {name=x488}
C {openDVS_pixel2x2.sym} 3060 7800 0 0 {name=x489}
C {openDVS_pixel2x2.sym} 3400 7800 0 0 {name=x490}
C {openDVS_pixel2x2.sym} 3740 7800 0 0 {name=x491}
C {openDVS_pixel2x2.sym} 4080 7800 0 0 {name=x492}
C {openDVS_pixel2x2.sym} 4420 7800 0 0 {name=x493}
C {openDVS_pixel2x2.sym} 4760 7800 0 0 {name=x494}
C {openDVS_pixel2x2.sym} 5100 7800 0 0 {name=x495}
C {openDVS_pixel2x2.sym} 5440 7800 0 0 {name=x496}
C {openDVS_pixel2x2.sym} 5780 7800 0 0 {name=x497}
C {openDVS_pixel2x2.sym} 6120 7800 0 0 {name=x498}
C {openDVS_pixel2x2.sym} 6460 7800 0 0 {name=x499}
C {openDVS_pixel2x2.sym} 6800 7800 0 0 {name=x500}
C {openDVS_pixel2x2.sym} 7140 7800 0 0 {name=x501}
C {openDVS_pixel2x2.sym} 7480 7800 0 0 {name=x502}
C {openDVS_pixel2x2.sym} 7820 7800 0 0 {name=x503}
C {openDVS_pixel2x2.sym} 8160 7800 0 0 {name=x504}
C {openDVS_pixel2x2.sym} 8500 7800 0 0 {name=x505}
C {openDVS_pixel2x2.sym} 8840 7800 0 0 {name=x506}
C {openDVS_pixel2x2.sym} 9180 7800 0 0 {name=x507}
C {openDVS_pixel2x2.sym} 9520 7800 0 0 {name=x508}
C {openDVS_pixel2x2.sym} 9860 7800 0 0 {name=x509}
C {openDVS_pixel2x2.sym} 10200 7800 0 0 {name=x510}
C {openDVS_pixel2x2.sym} 10540 7800 0 0 {name=x511}
C {openDVS_pixel2x2.sym} 0 8320 0 0 {name=x512}
C {openDVS_pixel2x2.sym} 340 8320 0 0 {name=x513}
C {openDVS_pixel2x2.sym} 680 8320 0 0 {name=x514}
C {openDVS_pixel2x2.sym} 1020 8320 0 0 {name=x515}
C {openDVS_pixel2x2.sym} 1360 8320 0 0 {name=x516}
C {openDVS_pixel2x2.sym} 1700 8320 0 0 {name=x517}
C {openDVS_pixel2x2.sym} 2040 8320 0 0 {name=x518}
C {openDVS_pixel2x2.sym} 2380 8320 0 0 {name=x519}
C {openDVS_pixel2x2.sym} 2720 8320 0 0 {name=x520}
C {openDVS_pixel2x2.sym} 3060 8320 0 0 {name=x521}
C {openDVS_pixel2x2.sym} 3400 8320 0 0 {name=x522}
C {openDVS_pixel2x2.sym} 3740 8320 0 0 {name=x523}
C {openDVS_pixel2x2.sym} 4080 8320 0 0 {name=x524}
C {openDVS_pixel2x2.sym} 4420 8320 0 0 {name=x525}
C {openDVS_pixel2x2.sym} 4760 8320 0 0 {name=x526}
C {openDVS_pixel2x2.sym} 5100 8320 0 0 {name=x527}
C {openDVS_pixel2x2.sym} 5440 8320 0 0 {name=x528}
C {openDVS_pixel2x2.sym} 5780 8320 0 0 {name=x529}
C {openDVS_pixel2x2.sym} 6120 8320 0 0 {name=x530}
C {openDVS_pixel2x2.sym} 6460 8320 0 0 {name=x531}
C {openDVS_pixel2x2.sym} 6800 8320 0 0 {name=x532}
C {openDVS_pixel2x2.sym} 7140 8320 0 0 {name=x533}
C {openDVS_pixel2x2.sym} 7480 8320 0 0 {name=x534}
C {openDVS_pixel2x2.sym} 7820 8320 0 0 {name=x535}
C {openDVS_pixel2x2.sym} 8160 8320 0 0 {name=x536}
C {openDVS_pixel2x2.sym} 8500 8320 0 0 {name=x537}
C {openDVS_pixel2x2.sym} 8840 8320 0 0 {name=x538}
C {openDVS_pixel2x2.sym} 9180 8320 0 0 {name=x539}
C {openDVS_pixel2x2.sym} 9520 8320 0 0 {name=x540}
C {openDVS_pixel2x2.sym} 9860 8320 0 0 {name=x541}
C {openDVS_pixel2x2.sym} 10200 8320 0 0 {name=x542}
C {openDVS_pixel2x2.sym} 10540 8320 0 0 {name=x543}
C {openDVS_pixel2x2.sym} 0 8840 0 0 {name=x544}
C {openDVS_pixel2x2.sym} 340 8840 0 0 {name=x545}
C {openDVS_pixel2x2.sym} 680 8840 0 0 {name=x546}
C {openDVS_pixel2x2.sym} 1020 8840 0 0 {name=x547}
C {openDVS_pixel2x2.sym} 1360 8840 0 0 {name=x548}
C {openDVS_pixel2x2.sym} 1700 8840 0 0 {name=x549}
C {openDVS_pixel2x2.sym} 2040 8840 0 0 {name=x550}
C {openDVS_pixel2x2.sym} 2380 8840 0 0 {name=x551}
C {openDVS_pixel2x2.sym} 2720 8840 0 0 {name=x552}
C {openDVS_pixel2x2.sym} 3060 8840 0 0 {name=x553}
C {openDVS_pixel2x2.sym} 3400 8840 0 0 {name=x554}
C {openDVS_pixel2x2.sym} 3740 8840 0 0 {name=x555}
C {openDVS_pixel2x2.sym} 4080 8840 0 0 {name=x556}
C {openDVS_pixel2x2.sym} 4420 8840 0 0 {name=x557}
C {openDVS_pixel2x2.sym} 4760 8840 0 0 {name=x558}
C {openDVS_pixel2x2.sym} 5100 8840 0 0 {name=x559}
C {openDVS_pixel2x2.sym} 5440 8840 0 0 {name=x560}
C {openDVS_pixel2x2.sym} 5780 8840 0 0 {name=x561}
C {openDVS_pixel2x2.sym} 6120 8840 0 0 {name=x562}
C {openDVS_pixel2x2.sym} 6460 8840 0 0 {name=x563}
C {openDVS_pixel2x2.sym} 6800 8840 0 0 {name=x564}
C {openDVS_pixel2x2.sym} 7140 8840 0 0 {name=x565}
C {openDVS_pixel2x2.sym} 7480 8840 0 0 {name=x566}
C {openDVS_pixel2x2.sym} 7820 8840 0 0 {name=x567}
C {openDVS_pixel2x2.sym} 8160 8840 0 0 {name=x568}
C {openDVS_pixel2x2.sym} 8500 8840 0 0 {name=x569}
C {openDVS_pixel2x2.sym} 8840 8840 0 0 {name=x570}
C {openDVS_pixel2x2.sym} 9180 8840 0 0 {name=x571}
C {openDVS_pixel2x2.sym} 9520 8840 0 0 {name=x572}
C {openDVS_pixel2x2.sym} 9860 8840 0 0 {name=x573}
C {openDVS_pixel2x2.sym} 10200 8840 0 0 {name=x574}
C {openDVS_pixel2x2.sym} 10540 8840 0 0 {name=x575}
C {openDVS_pixel2x2.sym} 0 9360 0 0 {name=x576}
C {openDVS_pixel2x2.sym} 340 9360 0 0 {name=x577}
C {openDVS_pixel2x2.sym} 680 9360 0 0 {name=x578}
C {openDVS_pixel2x2.sym} 1020 9360 0 0 {name=x579}
C {openDVS_pixel2x2.sym} 1360 9360 0 0 {name=x580}
C {openDVS_pixel2x2.sym} 1700 9360 0 0 {name=x581}
C {openDVS_pixel2x2.sym} 2040 9360 0 0 {name=x582}
C {openDVS_pixel2x2.sym} 2380 9360 0 0 {name=x583}
C {openDVS_pixel2x2.sym} 2720 9360 0 0 {name=x584}
C {openDVS_pixel2x2.sym} 3060 9360 0 0 {name=x585}
C {openDVS_pixel2x2.sym} 3400 9360 0 0 {name=x586}
C {openDVS_pixel2x2.sym} 3740 9360 0 0 {name=x587}
C {openDVS_pixel2x2.sym} 4080 9360 0 0 {name=x588}
C {openDVS_pixel2x2.sym} 4420 9360 0 0 {name=x589}
C {openDVS_pixel2x2.sym} 4760 9360 0 0 {name=x590}
C {openDVS_pixel2x2.sym} 5100 9360 0 0 {name=x591}
C {openDVS_pixel2x2.sym} 5440 9360 0 0 {name=x592}
C {openDVS_pixel2x2.sym} 5780 9360 0 0 {name=x593}
C {openDVS_pixel2x2.sym} 6120 9360 0 0 {name=x594}
C {openDVS_pixel2x2.sym} 6460 9360 0 0 {name=x595}
C {openDVS_pixel2x2.sym} 6800 9360 0 0 {name=x596}
C {openDVS_pixel2x2.sym} 7140 9360 0 0 {name=x597}
C {openDVS_pixel2x2.sym} 7480 9360 0 0 {name=x598}
C {openDVS_pixel2x2.sym} 7820 9360 0 0 {name=x599}
C {openDVS_pixel2x2.sym} 8160 9360 0 0 {name=x600}
C {openDVS_pixel2x2.sym} 8500 9360 0 0 {name=x601}
C {openDVS_pixel2x2.sym} 8840 9360 0 0 {name=x602}
C {openDVS_pixel2x2.sym} 9180 9360 0 0 {name=x603}
C {openDVS_pixel2x2.sym} 9520 9360 0 0 {name=x604}
C {openDVS_pixel2x2.sym} 9860 9360 0 0 {name=x605}
C {openDVS_pixel2x2.sym} 10200 9360 0 0 {name=x606}
C {openDVS_pixel2x2.sym} 10540 9360 0 0 {name=x607}
C {openDVS_pixel2x2.sym} 0 9880 0 0 {name=x608}
C {openDVS_pixel2x2.sym} 340 9880 0 0 {name=x609}
C {openDVS_pixel2x2.sym} 680 9880 0 0 {name=x610}
C {openDVS_pixel2x2.sym} 1020 9880 0 0 {name=x611}
C {openDVS_pixel2x2.sym} 1360 9880 0 0 {name=x612}
C {openDVS_pixel2x2.sym} 1700 9880 0 0 {name=x613}
C {openDVS_pixel2x2.sym} 2040 9880 0 0 {name=x614}
C {openDVS_pixel2x2.sym} 2380 9880 0 0 {name=x615}
C {openDVS_pixel2x2.sym} 2720 9880 0 0 {name=x616}
C {openDVS_pixel2x2.sym} 3060 9880 0 0 {name=x617}
C {openDVS_pixel2x2.sym} 3400 9880 0 0 {name=x618}
C {openDVS_pixel2x2.sym} 3740 9880 0 0 {name=x619}
C {openDVS_pixel2x2.sym} 4080 9880 0 0 {name=x620}
C {openDVS_pixel2x2.sym} 4420 9880 0 0 {name=x621}
C {openDVS_pixel2x2.sym} 4760 9880 0 0 {name=x622}
C {openDVS_pixel2x2.sym} 5100 9880 0 0 {name=x623}
C {openDVS_pixel2x2.sym} 5440 9880 0 0 {name=x624}
C {openDVS_pixel2x2.sym} 5780 9880 0 0 {name=x625}
C {openDVS_pixel2x2.sym} 6120 9880 0 0 {name=x626}
C {openDVS_pixel2x2.sym} 6460 9880 0 0 {name=x627}
C {openDVS_pixel2x2.sym} 6800 9880 0 0 {name=x628}
C {openDVS_pixel2x2.sym} 7140 9880 0 0 {name=x629}
C {openDVS_pixel2x2.sym} 7480 9880 0 0 {name=x630}
C {openDVS_pixel2x2.sym} 7820 9880 0 0 {name=x631}
C {openDVS_pixel2x2.sym} 8160 9880 0 0 {name=x632}
C {openDVS_pixel2x2.sym} 8500 9880 0 0 {name=x633}
C {openDVS_pixel2x2.sym} 8840 9880 0 0 {name=x634}
C {openDVS_pixel2x2.sym} 9180 9880 0 0 {name=x635}
C {openDVS_pixel2x2.sym} 9520 9880 0 0 {name=x636}
C {openDVS_pixel2x2.sym} 9860 9880 0 0 {name=x637}
C {openDVS_pixel2x2.sym} 10200 9880 0 0 {name=x638}
C {openDVS_pixel2x2.sym} 10540 9880 0 0 {name=x639}
C {openDVS_pixel2x2.sym} 0 10400 0 0 {name=x640}
C {openDVS_pixel2x2.sym} 340 10400 0 0 {name=x641}
C {openDVS_pixel2x2.sym} 680 10400 0 0 {name=x642}
C {openDVS_pixel2x2.sym} 1020 10400 0 0 {name=x643}
C {openDVS_pixel2x2.sym} 1360 10400 0 0 {name=x644}
C {openDVS_pixel2x2.sym} 1700 10400 0 0 {name=x645}
C {openDVS_pixel2x2.sym} 2040 10400 0 0 {name=x646}
C {openDVS_pixel2x2.sym} 2380 10400 0 0 {name=x647}
C {openDVS_pixel2x2.sym} 2720 10400 0 0 {name=x648}
C {openDVS_pixel2x2.sym} 3060 10400 0 0 {name=x649}
C {openDVS_pixel2x2.sym} 3400 10400 0 0 {name=x650}
C {openDVS_pixel2x2.sym} 3740 10400 0 0 {name=x651}
C {openDVS_pixel2x2.sym} 4080 10400 0 0 {name=x652}
C {openDVS_pixel2x2.sym} 4420 10400 0 0 {name=x653}
C {openDVS_pixel2x2.sym} 4760 10400 0 0 {name=x654}
C {openDVS_pixel2x2.sym} 5100 10400 0 0 {name=x655}
C {openDVS_pixel2x2.sym} 5440 10400 0 0 {name=x656}
C {openDVS_pixel2x2.sym} 5780 10400 0 0 {name=x657}
C {openDVS_pixel2x2.sym} 6120 10400 0 0 {name=x658}
C {openDVS_pixel2x2.sym} 6460 10400 0 0 {name=x659}
C {openDVS_pixel2x2.sym} 6800 10400 0 0 {name=x660}
C {openDVS_pixel2x2.sym} 7140 10400 0 0 {name=x661}
C {openDVS_pixel2x2.sym} 7480 10400 0 0 {name=x662}
C {openDVS_pixel2x2.sym} 7820 10400 0 0 {name=x663}
C {openDVS_pixel2x2.sym} 8160 10400 0 0 {name=x664}
C {openDVS_pixel2x2.sym} 8500 10400 0 0 {name=x665}
C {openDVS_pixel2x2.sym} 8840 10400 0 0 {name=x666}
C {openDVS_pixel2x2.sym} 9180 10400 0 0 {name=x667}
C {openDVS_pixel2x2.sym} 9520 10400 0 0 {name=x668}
C {openDVS_pixel2x2.sym} 9860 10400 0 0 {name=x669}
C {openDVS_pixel2x2.sym} 10200 10400 0 0 {name=x670}
C {openDVS_pixel2x2.sym} 10540 10400 0 0 {name=x671}
C {openDVS_pixel2x2.sym} 0 10920 0 0 {name=x672}
C {openDVS_pixel2x2.sym} 340 10920 0 0 {name=x673}
C {openDVS_pixel2x2.sym} 680 10920 0 0 {name=x674}
C {openDVS_pixel2x2.sym} 1020 10920 0 0 {name=x675}
C {openDVS_pixel2x2.sym} 1360 10920 0 0 {name=x676}
C {openDVS_pixel2x2.sym} 1700 10920 0 0 {name=x677}
C {openDVS_pixel2x2.sym} 2040 10920 0 0 {name=x678}
C {openDVS_pixel2x2.sym} 2380 10920 0 0 {name=x679}
C {openDVS_pixel2x2.sym} 2720 10920 0 0 {name=x680}
C {openDVS_pixel2x2.sym} 3060 10920 0 0 {name=x681}
C {openDVS_pixel2x2.sym} 3400 10920 0 0 {name=x682}
C {openDVS_pixel2x2.sym} 3740 10920 0 0 {name=x683}
C {openDVS_pixel2x2.sym} 4080 10920 0 0 {name=x684}
C {openDVS_pixel2x2.sym} 4420 10920 0 0 {name=x685}
C {openDVS_pixel2x2.sym} 4760 10920 0 0 {name=x686}
C {openDVS_pixel2x2.sym} 5100 10920 0 0 {name=x687}
C {openDVS_pixel2x2.sym} 5440 10920 0 0 {name=x688}
C {openDVS_pixel2x2.sym} 5780 10920 0 0 {name=x689}
C {openDVS_pixel2x2.sym} 6120 10920 0 0 {name=x690}
C {openDVS_pixel2x2.sym} 6460 10920 0 0 {name=x691}
C {openDVS_pixel2x2.sym} 6800 10920 0 0 {name=x692}
C {openDVS_pixel2x2.sym} 7140 10920 0 0 {name=x693}
C {openDVS_pixel2x2.sym} 7480 10920 0 0 {name=x694}
C {openDVS_pixel2x2.sym} 7820 10920 0 0 {name=x695}
C {openDVS_pixel2x2.sym} 8160 10920 0 0 {name=x696}
C {openDVS_pixel2x2.sym} 8500 10920 0 0 {name=x697}
C {openDVS_pixel2x2.sym} 8840 10920 0 0 {name=x698}
C {openDVS_pixel2x2.sym} 9180 10920 0 0 {name=x699}
C {openDVS_pixel2x2.sym} 9520 10920 0 0 {name=x700}
C {openDVS_pixel2x2.sym} 9860 10920 0 0 {name=x701}
C {openDVS_pixel2x2.sym} 10200 10920 0 0 {name=x702}
C {openDVS_pixel2x2.sym} 10540 10920 0 0 {name=x703}
C {openDVS_pixel2x2.sym} 0 11440 0 0 {name=x704}
C {openDVS_pixel2x2.sym} 340 11440 0 0 {name=x705}
C {openDVS_pixel2x2.sym} 680 11440 0 0 {name=x706}
C {openDVS_pixel2x2.sym} 1020 11440 0 0 {name=x707}
C {openDVS_pixel2x2.sym} 1360 11440 0 0 {name=x708}
C {openDVS_pixel2x2.sym} 1700 11440 0 0 {name=x709}
C {openDVS_pixel2x2.sym} 2040 11440 0 0 {name=x710}
C {openDVS_pixel2x2.sym} 2380 11440 0 0 {name=x711}
C {openDVS_pixel2x2.sym} 2720 11440 0 0 {name=x712}
C {openDVS_pixel2x2.sym} 3060 11440 0 0 {name=x713}
C {openDVS_pixel2x2.sym} 3400 11440 0 0 {name=x714}
C {openDVS_pixel2x2.sym} 3740 11440 0 0 {name=x715}
C {openDVS_pixel2x2.sym} 4080 11440 0 0 {name=x716}
C {openDVS_pixel2x2.sym} 4420 11440 0 0 {name=x717}
C {openDVS_pixel2x2.sym} 4760 11440 0 0 {name=x718}
C {openDVS_pixel2x2.sym} 5100 11440 0 0 {name=x719}
C {openDVS_pixel2x2.sym} 5440 11440 0 0 {name=x720}
C {openDVS_pixel2x2.sym} 5780 11440 0 0 {name=x721}
C {openDVS_pixel2x2.sym} 6120 11440 0 0 {name=x722}
C {openDVS_pixel2x2.sym} 6460 11440 0 0 {name=x723}
C {openDVS_pixel2x2.sym} 6800 11440 0 0 {name=x724}
C {openDVS_pixel2x2.sym} 7140 11440 0 0 {name=x725}
C {openDVS_pixel2x2.sym} 7480 11440 0 0 {name=x726}
C {openDVS_pixel2x2.sym} 7820 11440 0 0 {name=x727}
C {openDVS_pixel2x2.sym} 8160 11440 0 0 {name=x728}
C {openDVS_pixel2x2.sym} 8500 11440 0 0 {name=x729}
C {openDVS_pixel2x2.sym} 8840 11440 0 0 {name=x730}
C {openDVS_pixel2x2.sym} 9180 11440 0 0 {name=x731}
C {openDVS_pixel2x2.sym} 9520 11440 0 0 {name=x732}
C {openDVS_pixel2x2.sym} 9860 11440 0 0 {name=x733}
C {openDVS_pixel2x2.sym} 10200 11440 0 0 {name=x734}
C {openDVS_pixel2x2.sym} 10540 11440 0 0 {name=x735}
C {openDVS_pixel2x2.sym} 0 11960 0 0 {name=x736}
C {openDVS_pixel2x2.sym} 340 11960 0 0 {name=x737}
C {openDVS_pixel2x2.sym} 680 11960 0 0 {name=x738}
C {openDVS_pixel2x2.sym} 1020 11960 0 0 {name=x739}
C {openDVS_pixel2x2.sym} 1360 11960 0 0 {name=x740}
C {openDVS_pixel2x2.sym} 1700 11960 0 0 {name=x741}
C {openDVS_pixel2x2.sym} 2040 11960 0 0 {name=x742}
C {openDVS_pixel2x2.sym} 2380 11960 0 0 {name=x743}
C {openDVS_pixel2x2.sym} 2720 11960 0 0 {name=x744}
C {openDVS_pixel2x2.sym} 3060 11960 0 0 {name=x745}
C {openDVS_pixel2x2.sym} 3400 11960 0 0 {name=x746}
C {openDVS_pixel2x2.sym} 3740 11960 0 0 {name=x747}
C {openDVS_pixel2x2.sym} 4080 11960 0 0 {name=x748}
C {openDVS_pixel2x2.sym} 4420 11960 0 0 {name=x749}
C {openDVS_pixel2x2.sym} 4760 11960 0 0 {name=x750}
C {openDVS_pixel2x2.sym} 5100 11960 0 0 {name=x751}
C {openDVS_pixel2x2.sym} 5440 11960 0 0 {name=x752}
C {openDVS_pixel2x2.sym} 5780 11960 0 0 {name=x753}
C {openDVS_pixel2x2.sym} 6120 11960 0 0 {name=x754}
C {openDVS_pixel2x2.sym} 6460 11960 0 0 {name=x755}
C {openDVS_pixel2x2.sym} 6800 11960 0 0 {name=x756}
C {openDVS_pixel2x2.sym} 7140 11960 0 0 {name=x757}
C {openDVS_pixel2x2.sym} 7480 11960 0 0 {name=x758}
C {openDVS_pixel2x2.sym} 7820 11960 0 0 {name=x759}
C {openDVS_pixel2x2.sym} 8160 11960 0 0 {name=x760}
C {openDVS_pixel2x2.sym} 8500 11960 0 0 {name=x761}
C {openDVS_pixel2x2.sym} 8840 11960 0 0 {name=x762}
C {openDVS_pixel2x2.sym} 9180 11960 0 0 {name=x763}
C {openDVS_pixel2x2.sym} 9520 11960 0 0 {name=x764}
C {openDVS_pixel2x2.sym} 9860 11960 0 0 {name=x765}
C {openDVS_pixel2x2.sym} 10200 11960 0 0 {name=x766}
C {openDVS_pixel2x2.sym} 10540 11960 0 0 {name=x767}
C {openDVS_pixel2x2.sym} 0 12480 0 0 {name=x768}
C {openDVS_pixel2x2.sym} 340 12480 0 0 {name=x769}
C {openDVS_pixel2x2.sym} 680 12480 0 0 {name=x770}
C {openDVS_pixel2x2.sym} 1020 12480 0 0 {name=x771}
C {openDVS_pixel2x2.sym} 1360 12480 0 0 {name=x772}
C {openDVS_pixel2x2.sym} 1700 12480 0 0 {name=x773}
C {openDVS_pixel2x2.sym} 2040 12480 0 0 {name=x774}
C {openDVS_pixel2x2.sym} 2380 12480 0 0 {name=x775}
C {openDVS_pixel2x2.sym} 2720 12480 0 0 {name=x776}
C {openDVS_pixel2x2.sym} 3060 12480 0 0 {name=x777}
C {openDVS_pixel2x2.sym} 3400 12480 0 0 {name=x778}
C {openDVS_pixel2x2.sym} 3740 12480 0 0 {name=x779}
C {openDVS_pixel2x2.sym} 4080 12480 0 0 {name=x780}
C {openDVS_pixel2x2.sym} 4420 12480 0 0 {name=x781}
C {openDVS_pixel2x2.sym} 4760 12480 0 0 {name=x782}
C {openDVS_pixel2x2.sym} 5100 12480 0 0 {name=x783}
C {openDVS_pixel2x2.sym} 5440 12480 0 0 {name=x784}
C {openDVS_pixel2x2.sym} 5780 12480 0 0 {name=x785}
C {openDVS_pixel2x2.sym} 6120 12480 0 0 {name=x786}
C {openDVS_pixel2x2.sym} 6460 12480 0 0 {name=x787}
C {openDVS_pixel2x2.sym} 6800 12480 0 0 {name=x788}
C {openDVS_pixel2x2.sym} 7140 12480 0 0 {name=x789}
C {openDVS_pixel2x2.sym} 7480 12480 0 0 {name=x790}
C {openDVS_pixel2x2.sym} 7820 12480 0 0 {name=x791}
C {openDVS_pixel2x2.sym} 8160 12480 0 0 {name=x792}
C {openDVS_pixel2x2.sym} 8500 12480 0 0 {name=x793}
C {openDVS_pixel2x2.sym} 8840 12480 0 0 {name=x794}
C {openDVS_pixel2x2.sym} 9180 12480 0 0 {name=x795}
C {openDVS_pixel2x2.sym} 9520 12480 0 0 {name=x796}
C {openDVS_pixel2x2.sym} 9860 12480 0 0 {name=x797}
C {openDVS_pixel2x2.sym} 10200 12480 0 0 {name=x798}
C {openDVS_pixel2x2.sym} 10540 12480 0 0 {name=x799}
C {openDVS_pixel2x2.sym} 0 13000 0 0 {name=x800}
C {openDVS_pixel2x2.sym} 340 13000 0 0 {name=x801}
C {openDVS_pixel2x2.sym} 680 13000 0 0 {name=x802}
C {openDVS_pixel2x2.sym} 1020 13000 0 0 {name=x803}
C {openDVS_pixel2x2.sym} 1360 13000 0 0 {name=x804}
C {openDVS_pixel2x2.sym} 1700 13000 0 0 {name=x805}
C {openDVS_pixel2x2.sym} 2040 13000 0 0 {name=x806}
C {openDVS_pixel2x2.sym} 2380 13000 0 0 {name=x807}
C {openDVS_pixel2x2.sym} 2720 13000 0 0 {name=x808}
C {openDVS_pixel2x2.sym} 3060 13000 0 0 {name=x809}
C {openDVS_pixel2x2.sym} 3400 13000 0 0 {name=x810}
C {openDVS_pixel2x2.sym} 3740 13000 0 0 {name=x811}
C {openDVS_pixel2x2.sym} 4080 13000 0 0 {name=x812}
C {openDVS_pixel2x2.sym} 4420 13000 0 0 {name=x813}
C {openDVS_pixel2x2.sym} 4760 13000 0 0 {name=x814}
C {openDVS_pixel2x2.sym} 5100 13000 0 0 {name=x815}
C {openDVS_pixel2x2.sym} 5440 13000 0 0 {name=x816}
C {openDVS_pixel2x2.sym} 5780 13000 0 0 {name=x817}
C {openDVS_pixel2x2.sym} 6120 13000 0 0 {name=x818}
C {openDVS_pixel2x2.sym} 6460 13000 0 0 {name=x819}
C {openDVS_pixel2x2.sym} 6800 13000 0 0 {name=x820}
C {openDVS_pixel2x2.sym} 7140 13000 0 0 {name=x821}
C {openDVS_pixel2x2.sym} 7480 13000 0 0 {name=x822}
C {openDVS_pixel2x2.sym} 7820 13000 0 0 {name=x823}
C {openDVS_pixel2x2.sym} 8160 13000 0 0 {name=x824}
C {openDVS_pixel2x2.sym} 8500 13000 0 0 {name=x825}
C {openDVS_pixel2x2.sym} 8840 13000 0 0 {name=x826}
C {openDVS_pixel2x2.sym} 9180 13000 0 0 {name=x827}
C {openDVS_pixel2x2.sym} 9520 13000 0 0 {name=x828}
C {openDVS_pixel2x2.sym} 9860 13000 0 0 {name=x829}
C {openDVS_pixel2x2.sym} 10200 13000 0 0 {name=x830}
C {openDVS_pixel2x2.sym} 10540 13000 0 0 {name=x831}
C {openDVS_pixel2x2.sym} 0 13520 0 0 {name=x832}
C {openDVS_pixel2x2.sym} 340 13520 0 0 {name=x833}
C {openDVS_pixel2x2.sym} 680 13520 0 0 {name=x834}
C {openDVS_pixel2x2.sym} 1020 13520 0 0 {name=x835}
C {openDVS_pixel2x2.sym} 1360 13520 0 0 {name=x836}
C {openDVS_pixel2x2.sym} 1700 13520 0 0 {name=x837}
C {openDVS_pixel2x2.sym} 2040 13520 0 0 {name=x838}
C {openDVS_pixel2x2.sym} 2380 13520 0 0 {name=x839}
C {openDVS_pixel2x2.sym} 2720 13520 0 0 {name=x840}
C {openDVS_pixel2x2.sym} 3060 13520 0 0 {name=x841}
C {openDVS_pixel2x2.sym} 3400 13520 0 0 {name=x842}
C {openDVS_pixel2x2.sym} 3740 13520 0 0 {name=x843}
C {openDVS_pixel2x2.sym} 4080 13520 0 0 {name=x844}
C {openDVS_pixel2x2.sym} 4420 13520 0 0 {name=x845}
C {openDVS_pixel2x2.sym} 4760 13520 0 0 {name=x846}
C {openDVS_pixel2x2.sym} 5100 13520 0 0 {name=x847}
C {openDVS_pixel2x2.sym} 5440 13520 0 0 {name=x848}
C {openDVS_pixel2x2.sym} 5780 13520 0 0 {name=x849}
C {openDVS_pixel2x2.sym} 6120 13520 0 0 {name=x850}
C {openDVS_pixel2x2.sym} 6460 13520 0 0 {name=x851}
C {openDVS_pixel2x2.sym} 6800 13520 0 0 {name=x852}
C {openDVS_pixel2x2.sym} 7140 13520 0 0 {name=x853}
C {openDVS_pixel2x2.sym} 7480 13520 0 0 {name=x854}
C {openDVS_pixel2x2.sym} 7820 13520 0 0 {name=x855}
C {openDVS_pixel2x2.sym} 8160 13520 0 0 {name=x856}
C {openDVS_pixel2x2.sym} 8500 13520 0 0 {name=x857}
C {openDVS_pixel2x2.sym} 8840 13520 0 0 {name=x858}
C {openDVS_pixel2x2.sym} 9180 13520 0 0 {name=x859}
C {openDVS_pixel2x2.sym} 9520 13520 0 0 {name=x860}
C {openDVS_pixel2x2.sym} 9860 13520 0 0 {name=x861}
C {openDVS_pixel2x2.sym} 10200 13520 0 0 {name=x862}
C {openDVS_pixel2x2.sym} 10540 13520 0 0 {name=x863}
C {openDVS_pixel2x2.sym} 0 14040 0 0 {name=x864}
C {openDVS_pixel2x2.sym} 340 14040 0 0 {name=x865}
C {openDVS_pixel2x2.sym} 680 14040 0 0 {name=x866}
C {openDVS_pixel2x2.sym} 1020 14040 0 0 {name=x867}
C {openDVS_pixel2x2.sym} 1360 14040 0 0 {name=x868}
C {openDVS_pixel2x2.sym} 1700 14040 0 0 {name=x869}
C {openDVS_pixel2x2.sym} 2040 14040 0 0 {name=x870}
C {openDVS_pixel2x2.sym} 2380 14040 0 0 {name=x871}
C {openDVS_pixel2x2.sym} 2720 14040 0 0 {name=x872}
C {openDVS_pixel2x2.sym} 3060 14040 0 0 {name=x873}
C {openDVS_pixel2x2.sym} 3400 14040 0 0 {name=x874}
C {openDVS_pixel2x2.sym} 3740 14040 0 0 {name=x875}
C {openDVS_pixel2x2.sym} 4080 14040 0 0 {name=x876}
C {openDVS_pixel2x2.sym} 4420 14040 0 0 {name=x877}
C {openDVS_pixel2x2.sym} 4760 14040 0 0 {name=x878}
C {openDVS_pixel2x2.sym} 5100 14040 0 0 {name=x879}
C {openDVS_pixel2x2.sym} 5440 14040 0 0 {name=x880}
C {openDVS_pixel2x2.sym} 5780 14040 0 0 {name=x881}
C {openDVS_pixel2x2.sym} 6120 14040 0 0 {name=x882}
C {openDVS_pixel2x2.sym} 6460 14040 0 0 {name=x883}
C {openDVS_pixel2x2.sym} 6800 14040 0 0 {name=x884}
C {openDVS_pixel2x2.sym} 7140 14040 0 0 {name=x885}
C {openDVS_pixel2x2.sym} 7480 14040 0 0 {name=x886}
C {openDVS_pixel2x2.sym} 7820 14040 0 0 {name=x887}
C {openDVS_pixel2x2.sym} 8160 14040 0 0 {name=x888}
C {openDVS_pixel2x2.sym} 8500 14040 0 0 {name=x889}
C {openDVS_pixel2x2.sym} 8840 14040 0 0 {name=x890}
C {openDVS_pixel2x2.sym} 9180 14040 0 0 {name=x891}
C {openDVS_pixel2x2.sym} 9520 14040 0 0 {name=x892}
C {openDVS_pixel2x2.sym} 9860 14040 0 0 {name=x893}
C {openDVS_pixel2x2.sym} 10200 14040 0 0 {name=x894}
C {openDVS_pixel2x2.sym} 10540 14040 0 0 {name=x895}
C {openDVS_pixel2x2.sym} 0 14560 0 0 {name=x896}
C {openDVS_pixel2x2.sym} 340 14560 0 0 {name=x897}
C {openDVS_pixel2x2.sym} 680 14560 0 0 {name=x898}
C {openDVS_pixel2x2.sym} 1020 14560 0 0 {name=x899}
C {openDVS_pixel2x2.sym} 1360 14560 0 0 {name=x900}
C {openDVS_pixel2x2.sym} 1700 14560 0 0 {name=x901}
C {openDVS_pixel2x2.sym} 2040 14560 0 0 {name=x902}
C {openDVS_pixel2x2.sym} 2380 14560 0 0 {name=x903}
C {openDVS_pixel2x2.sym} 2720 14560 0 0 {name=x904}
C {openDVS_pixel2x2.sym} 3060 14560 0 0 {name=x905}
C {openDVS_pixel2x2.sym} 3400 14560 0 0 {name=x906}
C {openDVS_pixel2x2.sym} 3740 14560 0 0 {name=x907}
C {openDVS_pixel2x2.sym} 4080 14560 0 0 {name=x908}
C {openDVS_pixel2x2.sym} 4420 14560 0 0 {name=x909}
C {openDVS_pixel2x2.sym} 4760 14560 0 0 {name=x910}
C {openDVS_pixel2x2.sym} 5100 14560 0 0 {name=x911}
C {openDVS_pixel2x2.sym} 5440 14560 0 0 {name=x912}
C {openDVS_pixel2x2.sym} 5780 14560 0 0 {name=x913}
C {openDVS_pixel2x2.sym} 6120 14560 0 0 {name=x914}
C {openDVS_pixel2x2.sym} 6460 14560 0 0 {name=x915}
C {openDVS_pixel2x2.sym} 6800 14560 0 0 {name=x916}
C {openDVS_pixel2x2.sym} 7140 14560 0 0 {name=x917}
C {openDVS_pixel2x2.sym} 7480 14560 0 0 {name=x918}
C {openDVS_pixel2x2.sym} 7820 14560 0 0 {name=x919}
C {openDVS_pixel2x2.sym} 8160 14560 0 0 {name=x920}
C {openDVS_pixel2x2.sym} 8500 14560 0 0 {name=x921}
C {openDVS_pixel2x2.sym} 8840 14560 0 0 {name=x922}
C {openDVS_pixel2x2.sym} 9180 14560 0 0 {name=x923}
C {openDVS_pixel2x2.sym} 9520 14560 0 0 {name=x924}
C {openDVS_pixel2x2.sym} 9860 14560 0 0 {name=x925}
C {openDVS_pixel2x2.sym} 10200 14560 0 0 {name=x926}
C {openDVS_pixel2x2.sym} 10540 14560 0 0 {name=x927}
C {openDVS_pixel2x2.sym} 0 15080 0 0 {name=x928}
C {openDVS_pixel2x2.sym} 340 15080 0 0 {name=x929}
C {openDVS_pixel2x2.sym} 680 15080 0 0 {name=x930}
C {openDVS_pixel2x2.sym} 1020 15080 0 0 {name=x931}
C {openDVS_pixel2x2.sym} 1360 15080 0 0 {name=x932}
C {openDVS_pixel2x2.sym} 1700 15080 0 0 {name=x933}
C {openDVS_pixel2x2.sym} 2040 15080 0 0 {name=x934}
C {openDVS_pixel2x2.sym} 2380 15080 0 0 {name=x935}
C {openDVS_pixel2x2.sym} 2720 15080 0 0 {name=x936}
C {openDVS_pixel2x2.sym} 3060 15080 0 0 {name=x937}
C {openDVS_pixel2x2.sym} 3400 15080 0 0 {name=x938}
C {openDVS_pixel2x2.sym} 3740 15080 0 0 {name=x939}
C {openDVS_pixel2x2.sym} 4080 15080 0 0 {name=x940}
C {openDVS_pixel2x2.sym} 4420 15080 0 0 {name=x941}
C {openDVS_pixel2x2.sym} 4760 15080 0 0 {name=x942}
C {openDVS_pixel2x2.sym} 5100 15080 0 0 {name=x943}
C {openDVS_pixel2x2.sym} 5440 15080 0 0 {name=x944}
C {openDVS_pixel2x2.sym} 5780 15080 0 0 {name=x945}
C {openDVS_pixel2x2.sym} 6120 15080 0 0 {name=x946}
C {openDVS_pixel2x2.sym} 6460 15080 0 0 {name=x947}
C {openDVS_pixel2x2.sym} 6800 15080 0 0 {name=x948}
C {openDVS_pixel2x2.sym} 7140 15080 0 0 {name=x949}
C {openDVS_pixel2x2.sym} 7480 15080 0 0 {name=x950}
C {openDVS_pixel2x2.sym} 7820 15080 0 0 {name=x951}
C {openDVS_pixel2x2.sym} 8160 15080 0 0 {name=x952}
C {openDVS_pixel2x2.sym} 8500 15080 0 0 {name=x953}
C {openDVS_pixel2x2.sym} 8840 15080 0 0 {name=x954}
C {openDVS_pixel2x2.sym} 9180 15080 0 0 {name=x955}
C {openDVS_pixel2x2.sym} 9520 15080 0 0 {name=x956}
C {openDVS_pixel2x2.sym} 9860 15080 0 0 {name=x957}
C {openDVS_pixel2x2.sym} 10200 15080 0 0 {name=x958}
C {openDVS_pixel2x2.sym} 10540 15080 0 0 {name=x959}
C {openDVS_pixel2x2.sym} 0 15600 0 0 {name=x960}
C {openDVS_pixel2x2.sym} 340 15600 0 0 {name=x961}
C {openDVS_pixel2x2.sym} 680 15600 0 0 {name=x962}
C {openDVS_pixel2x2.sym} 1020 15600 0 0 {name=x963}
C {openDVS_pixel2x2.sym} 1360 15600 0 0 {name=x964}
C {openDVS_pixel2x2.sym} 1700 15600 0 0 {name=x965}
C {openDVS_pixel2x2.sym} 2040 15600 0 0 {name=x966}
C {openDVS_pixel2x2.sym} 2380 15600 0 0 {name=x967}
C {openDVS_pixel2x2.sym} 2720 15600 0 0 {name=x968}
C {openDVS_pixel2x2.sym} 3060 15600 0 0 {name=x969}
C {openDVS_pixel2x2.sym} 3400 15600 0 0 {name=x970}
C {openDVS_pixel2x2.sym} 3740 15600 0 0 {name=x971}
C {openDVS_pixel2x2.sym} 4080 15600 0 0 {name=x972}
C {openDVS_pixel2x2.sym} 4420 15600 0 0 {name=x973}
C {openDVS_pixel2x2.sym} 4760 15600 0 0 {name=x974}
C {openDVS_pixel2x2.sym} 5100 15600 0 0 {name=x975}
C {openDVS_pixel2x2.sym} 5440 15600 0 0 {name=x976}
C {openDVS_pixel2x2.sym} 5780 15600 0 0 {name=x977}
C {openDVS_pixel2x2.sym} 6120 15600 0 0 {name=x978}
C {openDVS_pixel2x2.sym} 6460 15600 0 0 {name=x979}
C {openDVS_pixel2x2.sym} 6800 15600 0 0 {name=x980}
C {openDVS_pixel2x2.sym} 7140 15600 0 0 {name=x981}
C {openDVS_pixel2x2.sym} 7480 15600 0 0 {name=x982}
C {openDVS_pixel2x2.sym} 7820 15600 0 0 {name=x983}
C {openDVS_pixel2x2.sym} 8160 15600 0 0 {name=x984}
C {openDVS_pixel2x2.sym} 8500 15600 0 0 {name=x985}
C {openDVS_pixel2x2.sym} 8840 15600 0 0 {name=x986}
C {openDVS_pixel2x2.sym} 9180 15600 0 0 {name=x987}
C {openDVS_pixel2x2.sym} 9520 15600 0 0 {name=x988}
C {openDVS_pixel2x2.sym} 9860 15600 0 0 {name=x989}
C {openDVS_pixel2x2.sym} 10200 15600 0 0 {name=x990}
C {openDVS_pixel2x2.sym} 10540 15600 0 0 {name=x991}
C {openDVS_pixel2x2.sym} 0 16120 0 0 {name=x992}
C {openDVS_pixel2x2.sym} 340 16120 0 0 {name=x993}
C {openDVS_pixel2x2.sym} 680 16120 0 0 {name=x994}
C {openDVS_pixel2x2.sym} 1020 16120 0 0 {name=x995}
C {openDVS_pixel2x2.sym} 1360 16120 0 0 {name=x996}
C {openDVS_pixel2x2.sym} 1700 16120 0 0 {name=x997}
C {openDVS_pixel2x2.sym} 2040 16120 0 0 {name=x998}
C {openDVS_pixel2x2.sym} 2380 16120 0 0 {name=x999}
C {openDVS_pixel2x2.sym} 2720 16120 0 0 {name=x1000}
C {openDVS_pixel2x2.sym} 3060 16120 0 0 {name=x1001}
C {openDVS_pixel2x2.sym} 3400 16120 0 0 {name=x1002}
C {openDVS_pixel2x2.sym} 3740 16120 0 0 {name=x1003}
C {openDVS_pixel2x2.sym} 4080 16120 0 0 {name=x1004}
C {openDVS_pixel2x2.sym} 4420 16120 0 0 {name=x1005}
C {openDVS_pixel2x2.sym} 4760 16120 0 0 {name=x1006}
C {openDVS_pixel2x2.sym} 5100 16120 0 0 {name=x1007}
C {openDVS_pixel2x2.sym} 5440 16120 0 0 {name=x1008}
C {openDVS_pixel2x2.sym} 5780 16120 0 0 {name=x1009}
C {openDVS_pixel2x2.sym} 6120 16120 0 0 {name=x1010}
C {openDVS_pixel2x2.sym} 6460 16120 0 0 {name=x1011}
C {openDVS_pixel2x2.sym} 6800 16120 0 0 {name=x1012}
C {openDVS_pixel2x2.sym} 7140 16120 0 0 {name=x1013}
C {openDVS_pixel2x2.sym} 7480 16120 0 0 {name=x1014}
C {openDVS_pixel2x2.sym} 7820 16120 0 0 {name=x1015}
C {openDVS_pixel2x2.sym} 8160 16120 0 0 {name=x1016}
C {openDVS_pixel2x2.sym} 8500 16120 0 0 {name=x1017}
C {openDVS_pixel2x2.sym} 8840 16120 0 0 {name=x1018}
C {openDVS_pixel2x2.sym} 9180 16120 0 0 {name=x1019}
C {openDVS_pixel2x2.sym} 9520 16120 0 0 {name=x1020}
C {openDVS_pixel2x2.sym} 9860 16120 0 0 {name=x1021}
C {openDVS_pixel2x2.sym} 10200 16120 0 0 {name=x1022}
C {openDVS_pixel2x2.sym} 10540 16120 0 0 {name=x1023}
C {iopin.sym} -500 -680 3 0 {name=p12 lab=GND}
C {iopin.sym} -470 -680 3 0 {name=p13 lab=VDD}
C {iopin.sym} -280 -680 3 0 {name=p57 lab=OffBn}
C {iopin.sym} -300 -680 3 0 {name=p58 lab=OnBn}
C {iopin.sym} -320 -680 3 0 {name=p59 lab=DiffBn}
C {iopin.sym} -340 -680 3 0 {name=p60 lab=RefrBp}
C {iopin.sym} -360 -680 3 0 {name=p61 lab=PrSFBp}
C {iopin.sym} -380 -680 3 0 {name=p62 lab=PrBp}
C {lab_wire.sym} -60 -400 0 0 {name=p3 sig_type=std_logic lab=VDD}
C {lab_wire.sym} -60 -380 0 0 {name=p1 sig_type=std_logic lab=GND}
C {lab_wire.sym} -60 -360 0 0 {name=p2 sig_type=std_logic lab=GND}
C {lab_wire.sym} -60 -320 0 0 {name=p4 sig_type=std_logic lab=DiffBn}
C {lab_wire.sym} -60 -300 0 0 {name=p5 sig_type=std_logic lab=RefrBp}
C {lab_wire.sym} -60 -280 0 0 {name=p6 sig_type=std_logic lab=PrSFBp}
C {lab_wire.sym} -60 -260 0 0 {name=p7 sig_type=std_logic lab=OffBn}
C {lab_wire.sym} -60 -240 0 0 {name=p8 sig_type=std_logic lab=PrBp}
C {lab_wire.sym} -60 -220 0 0 {name=p9 sig_type=std_logic lab=OnBn}
C {lab_wire.sym} -60 -180 0 0 {name=p17 sig_type=std_logic lab=rowReadON[0]}
C {lab_wire.sym} -60 -160 0 0 {name=p18 sig_type=std_logic lab=rowReadOFF[0]}
C {lab_wire.sym} -60 -140 0 0 {name=p19 sig_type=std_logic lab=rowReadON[1]}
C {lab_wire.sym} -60 -120 0 0 {name=p20 sig_type=std_logic lab=rowReadOFF[1]}
C {lab_wire.sym} -60 340 0 0 {name=p21 sig_type=std_logic lab=rowReadON[2]}
C {lab_wire.sym} -60 360 0 0 {name=p22 sig_type=std_logic lab=rowReadOFF[2]}
C {lab_wire.sym} -60 380 0 0 {name=p23 sig_type=std_logic lab=rowReadON[3]}
C {lab_wire.sym} -60 400 0 0 {name=p24 sig_type=std_logic lab=rowReadOFF[3]}
C {lab_wire.sym} -60 860 0 0 {name=p25 sig_type=std_logic lab=rowReadON[4]}
C {lab_wire.sym} -60 880 0 0 {name=p26 sig_type=std_logic lab=rowReadOFF[4]}
C {lab_wire.sym} -60 900 0 0 {name=p27 sig_type=std_logic lab=rowReadON[5]}
C {lab_wire.sym} -60 920 0 0 {name=p28 sig_type=std_logic lab=rowReadOFF[5]}
C {lab_wire.sym} -60 1380 0 0 {name=p29 sig_type=std_logic lab=rowReadON[6]}
C {lab_wire.sym} -60 1400 0 0 {name=p30 sig_type=std_logic lab=rowReadOFF[6]}
C {lab_wire.sym} -60 1420 0 0 {name=p31 sig_type=std_logic lab=rowReadON[7]}
C {lab_wire.sym} -60 1440 0 0 {name=p32 sig_type=std_logic lab=rowReadOFF[7]}
C {lab_wire.sym} -60 1900 0 0 {name=p33 sig_type=std_logic lab=rowReadON[8]}
C {lab_wire.sym} -60 1920 0 0 {name=p34 sig_type=std_logic lab=rowReadOFF[8]}
C {lab_wire.sym} -60 1940 0 0 {name=p35 sig_type=std_logic lab=rowReadON[9]}
C {lab_wire.sym} -60 1960 0 0 {name=p36 sig_type=std_logic lab=rowReadOFF[9]}
C {lab_wire.sym} -60 2420 0 0 {name=p37 sig_type=std_logic lab=rowReadON[10]}
C {lab_wire.sym} -60 2440 0 0 {name=p38 sig_type=std_logic lab=rowReadOFF[10]}
C {lab_wire.sym} -60 2460 0 0 {name=p39 sig_type=std_logic lab=rowReadON[11]}
C {lab_wire.sym} -60 2480 0 0 {name=p40 sig_type=std_logic lab=rowReadOFF[11]}
C {lab_wire.sym} -60 2940 0 0 {name=p41 sig_type=std_logic lab=rowReadON[12]}
C {lab_wire.sym} -60 2960 0 0 {name=p42 sig_type=std_logic lab=rowReadOFF[12]}
C {lab_wire.sym} -60 2980 0 0 {name=p43 sig_type=std_logic lab=rowReadON[13]}
C {lab_wire.sym} -60 3000 0 0 {name=p44 sig_type=std_logic lab=rowReadOFF[13]}
C {lab_wire.sym} -60 3460 0 0 {name=p45 sig_type=std_logic lab=rowReadON[14]}
C {lab_wire.sym} -60 3480 0 0 {name=p46 sig_type=std_logic lab=rowReadOFF[14]}
C {lab_wire.sym} -60 3500 0 0 {name=p47 sig_type=std_logic lab=rowReadON[15]}
C {lab_wire.sym} -60 3520 0 0 {name=p48 sig_type=std_logic lab=rowReadOFF[15]}
C {lab_wire.sym} -60 3980 0 0 {name=p49 sig_type=std_logic lab=rowReadON[16]}
C {lab_wire.sym} -60 4000 0 0 {name=p50 sig_type=std_logic lab=rowReadOFF[16]}
C {lab_wire.sym} -60 4020 0 0 {name=p51 sig_type=std_logic lab=rowReadON[17]}
C {lab_wire.sym} -60 4040 0 0 {name=p52 sig_type=std_logic lab=rowReadOFF[17]}
C {lab_wire.sym} -60 4500 0 0 {name=p53 sig_type=std_logic lab=rowReadON[18]}
C {lab_wire.sym} -60 4520 0 0 {name=p54 sig_type=std_logic lab=rowReadOFF[18]}
C {lab_wire.sym} -60 4540 0 0 {name=p55 sig_type=std_logic lab=rowReadON[19]}
C {lab_wire.sym} -60 4560 0 0 {name=p56 sig_type=std_logic lab=rowReadOFF[19]}
C {lab_wire.sym} -60 5020 0 0 {name=p63 sig_type=std_logic lab=rowReadON[20]}
C {lab_wire.sym} -60 5040 0 0 {name=p64 sig_type=std_logic lab=rowReadOFF[20]}
C {lab_wire.sym} -60 5060 0 0 {name=p65 sig_type=std_logic lab=rowReadON[21]}
C {lab_wire.sym} -60 5080 0 0 {name=p66 sig_type=std_logic lab=rowReadOFF[21]}
C {lab_wire.sym} -60 5540 0 0 {name=p67 sig_type=std_logic lab=rowReadON[22]}
C {lab_wire.sym} -60 5560 0 0 {name=p68 sig_type=std_logic lab=rowReadOFF[22]}
C {lab_wire.sym} -60 5580 0 0 {name=p69 sig_type=std_logic lab=rowReadON[23]}
C {lab_wire.sym} -60 5600 0 0 {name=p70 sig_type=std_logic lab=rowReadOFF[23]}
C {lab_wire.sym} -60 6060 0 0 {name=p71 sig_type=std_logic lab=rowReadON[24]}
C {lab_wire.sym} -60 6080 0 0 {name=p72 sig_type=std_logic lab=rowReadOFF[24]}
C {lab_wire.sym} -60 6100 0 0 {name=p73 sig_type=std_logic lab=rowReadON[25]}
C {lab_wire.sym} -60 6120 0 0 {name=p74 sig_type=std_logic lab=rowReadOFF[25]}
C {lab_wire.sym} -60 6580 0 0 {name=p75 sig_type=std_logic lab=rowReadON[26]}
C {lab_wire.sym} -60 6600 0 0 {name=p76 sig_type=std_logic lab=rowReadOFF[26]}
C {lab_wire.sym} -60 6620 0 0 {name=p77 sig_type=std_logic lab=rowReadON[27]}
C {lab_wire.sym} -60 6640 0 0 {name=p78 sig_type=std_logic lab=rowReadOFF[27]}
C {lab_wire.sym} -60 7100 0 0 {name=p79 sig_type=std_logic lab=rowReadON[28]}
C {lab_wire.sym} -60 7120 0 0 {name=p80 sig_type=std_logic lab=rowReadOFF[28]}
C {lab_wire.sym} -60 7140 0 0 {name=p81 sig_type=std_logic lab=rowReadON[29]}
C {lab_wire.sym} -60 7160 0 0 {name=p82 sig_type=std_logic lab=rowReadOFF[29]}
C {lab_wire.sym} -60 7620 0 0 {name=p83 sig_type=std_logic lab=rowReadON[30]}
C {lab_wire.sym} -60 7640 0 0 {name=p84 sig_type=std_logic lab=rowReadOFF[30]}
C {lab_wire.sym} -60 7660 0 0 {name=p85 sig_type=std_logic lab=rowReadON[31]}
C {lab_wire.sym} -60 7680 0 0 {name=p86 sig_type=std_logic lab=rowReadOFF[31]}
C {lab_wire.sym} -60 8140 0 0 {name=p87 sig_type=std_logic lab=rowReadON[32]}
C {lab_wire.sym} -60 8160 0 0 {name=p88 sig_type=std_logic lab=rowReadOFF[32]}
C {lab_wire.sym} -60 8180 0 0 {name=p89 sig_type=std_logic lab=rowReadON[33]}
C {lab_wire.sym} -60 8200 0 0 {name=p90 sig_type=std_logic lab=rowReadOFF[33]}
C {lab_wire.sym} -60 8660 0 0 {name=p91 sig_type=std_logic lab=rowReadON[34]}
C {lab_wire.sym} -60 8680 0 0 {name=p92 sig_type=std_logic lab=rowReadOFF[34]}
C {lab_wire.sym} -60 8700 0 0 {name=p93 sig_type=std_logic lab=rowReadON[35]}
C {lab_wire.sym} -60 8720 0 0 {name=p94 sig_type=std_logic lab=rowReadOFF[35]}
C {lab_wire.sym} -60 9180 0 0 {name=p95 sig_type=std_logic lab=rowReadON[36]}
C {lab_wire.sym} -60 9200 0 0 {name=p96 sig_type=std_logic lab=rowReadOFF[36]}
C {lab_wire.sym} -60 9220 0 0 {name=p97 sig_type=std_logic lab=rowReadON[37]}
C {lab_wire.sym} -60 9240 0 0 {name=p98 sig_type=std_logic lab=rowReadOFF[37]}
C {lab_wire.sym} -60 9700 0 0 {name=p99 sig_type=std_logic lab=rowReadON[38]}
C {lab_wire.sym} -60 9720 0 0 {name=p100 sig_type=std_logic lab=rowReadOFF[38]}
C {lab_wire.sym} -60 9740 0 0 {name=p101 sig_type=std_logic lab=rowReadON[39]}
C {lab_wire.sym} -60 9760 0 0 {name=p102 sig_type=std_logic lab=rowReadOFF[39]}
C {lab_wire.sym} -60 10220 0 0 {name=p103 sig_type=std_logic lab=rowReadON[40]}
C {lab_wire.sym} -60 10240 0 0 {name=p104 sig_type=std_logic lab=rowReadOFF[40]}
C {lab_wire.sym} -60 10260 0 0 {name=p105 sig_type=std_logic lab=rowReadON[41]}
C {lab_wire.sym} -60 10280 0 0 {name=p106 sig_type=std_logic lab=rowReadOFF[41]}
C {lab_wire.sym} -60 10740 0 0 {name=p107 sig_type=std_logic lab=rowReadON[42]}
C {lab_wire.sym} -60 10760 0 0 {name=p108 sig_type=std_logic lab=rowReadOFF[42]}
C {lab_wire.sym} -60 10780 0 0 {name=p109 sig_type=std_logic lab=rowReadON[43]}
C {lab_wire.sym} -60 10800 0 0 {name=p110 sig_type=std_logic lab=rowReadOFF[43]}
C {lab_wire.sym} -60 11260 0 0 {name=p111 sig_type=std_logic lab=rowReadON[44]}
C {lab_wire.sym} -60 11280 0 0 {name=p112 sig_type=std_logic lab=rowReadOFF[44]}
C {lab_wire.sym} -60 11300 0 0 {name=p113 sig_type=std_logic lab=rowReadON[45]}
C {lab_wire.sym} -60 11320 0 0 {name=p114 sig_type=std_logic lab=rowReadOFF[45]}
C {lab_wire.sym} -60 11780 0 0 {name=p115 sig_type=std_logic lab=rowReadON[46]}
C {lab_wire.sym} -60 11800 0 0 {name=p116 sig_type=std_logic lab=rowReadOFF[46]}
C {lab_wire.sym} -60 11820 0 0 {name=p117 sig_type=std_logic lab=rowReadON[47]}
C {lab_wire.sym} -60 11840 0 0 {name=p118 sig_type=std_logic lab=rowReadOFF[47]}
C {lab_wire.sym} -60 12300 0 0 {name=p119 sig_type=std_logic lab=rowReadON[48]}
C {lab_wire.sym} -60 12320 0 0 {name=p120 sig_type=std_logic lab=rowReadOFF[48]}
C {lab_wire.sym} -60 12340 0 0 {name=p121 sig_type=std_logic lab=rowReadON[49]}
C {lab_wire.sym} -60 12360 0 0 {name=p122 sig_type=std_logic lab=rowReadOFF[49]}
C {lab_wire.sym} -60 12820 0 0 {name=p123 sig_type=std_logic lab=rowReadON[50]}
C {lab_wire.sym} -60 12840 0 0 {name=p124 sig_type=std_logic lab=rowReadOFF[50]}
C {lab_wire.sym} -60 12860 0 0 {name=p125 sig_type=std_logic lab=rowReadON[51]}
C {lab_wire.sym} -60 12880 0 0 {name=p126 sig_type=std_logic lab=rowReadOFF[51]}
C {lab_wire.sym} -60 13340 0 0 {name=p127 sig_type=std_logic lab=rowReadON[52]}
C {lab_wire.sym} -60 13360 0 0 {name=p128 sig_type=std_logic lab=rowReadOFF[52]}
C {lab_wire.sym} -60 13380 0 0 {name=p129 sig_type=std_logic lab=rowReadON[53]}
C {lab_wire.sym} -60 13400 0 0 {name=p130 sig_type=std_logic lab=rowReadOFF[53]}
C {lab_wire.sym} -60 13860 0 0 {name=p131 sig_type=std_logic lab=rowReadON[54]}
C {lab_wire.sym} -60 13880 0 0 {name=p132 sig_type=std_logic lab=rowReadOFF[54]}
C {lab_wire.sym} -60 13900 0 0 {name=p133 sig_type=std_logic lab=rowReadON[55]}
C {lab_wire.sym} -60 13920 0 0 {name=p134 sig_type=std_logic lab=rowReadOFF[55]}
C {lab_wire.sym} -60 14380 0 0 {name=p135 sig_type=std_logic lab=rowReadON[56]}
C {lab_wire.sym} -60 14400 0 0 {name=p136 sig_type=std_logic lab=rowReadOFF[56]}
C {lab_wire.sym} -60 14420 0 0 {name=p137 sig_type=std_logic lab=rowReadON[57]}
C {lab_wire.sym} -60 14440 0 0 {name=p138 sig_type=std_logic lab=rowReadOFF[57]}
C {lab_wire.sym} -60 14900 0 0 {name=p139 sig_type=std_logic lab=rowReadON[58]}
C {lab_wire.sym} -60 14920 0 0 {name=p140 sig_type=std_logic lab=rowReadOFF[58]}
C {lab_wire.sym} -60 14940 0 0 {name=p141 sig_type=std_logic lab=rowReadON[59]}
C {lab_wire.sym} -60 14960 0 0 {name=p142 sig_type=std_logic lab=rowReadOFF[59]}
C {lab_wire.sym} -60 15420 0 0 {name=p143 sig_type=std_logic lab=rowReadON[60]}
C {lab_wire.sym} -60 15440 0 0 {name=p144 sig_type=std_logic lab=rowReadOFF[60]}
C {lab_wire.sym} -60 15460 0 0 {name=p145 sig_type=std_logic lab=rowReadON[61]}
C {lab_wire.sym} -60 15480 0 0 {name=p146 sig_type=std_logic lab=rowReadOFF[61]}
C {lab_wire.sym} -60 15940 0 0 {name=p147 sig_type=std_logic lab=rowReadON[62]}
C {lab_wire.sym} -60 15960 0 0 {name=p148 sig_type=std_logic lab=rowReadOFF[62]}
C {lab_wire.sym} -60 15980 0 0 {name=p149 sig_type=std_logic lab=rowReadON[63]}
C {lab_wire.sym} -60 16000 0 0 {name=p150 sig_type=std_logic lab=rowReadOFF[63]}
C {col_amp_2x1.sym} 20 -540 0 0 {name=x1088}
C {col_amp_2x1.sym} 360 -540 0 0 {name=x1089}
C {col_amp_2x1.sym} 700 -540 0 0 {name=x1090}
C {col_amp_2x1.sym} 1040 -540 0 0 {name=x1091}
C {col_amp_2x1.sym} 1380 -540 0 0 {name=x1092}
C {col_amp_2x1.sym} 1720 -540 0 0 {name=x1093}
C {col_amp_2x1.sym} 2060 -540 0 0 {name=x1094}
C {col_amp_2x1.sym} 2400 -540 0 0 {name=x1095}
C {col_amp_2x1.sym} 2740 -540 0 0 {name=x1096}
C {col_amp_2x1.sym} 3080 -540 0 0 {name=x1097}
C {col_amp_2x1.sym} 3420 -540 0 0 {name=x1098}
C {col_amp_2x1.sym} 3760 -540 0 0 {name=x1099}
C {col_amp_2x1.sym} 4100 -540 0 0 {name=x1100}
C {col_amp_2x1.sym} 4440 -540 0 0 {name=x1101}
C {col_amp_2x1.sym} 4780 -540 0 0 {name=x1102}
C {col_amp_2x1.sym} 5120 -540 0 0 {name=x1103}
C {col_amp_2x1.sym} 5460 -540 0 0 {name=x1104}
C {col_amp_2x1.sym} 5800 -540 0 0 {name=x1105}
C {col_amp_2x1.sym} 6140 -540 0 0 {name=x1106}
C {col_amp_2x1.sym} 6480 -540 0 0 {name=x1107}
C {col_amp_2x1.sym} 6820 -540 0 0 {name=x1108}
C {col_amp_2x1.sym} 7160 -540 0 0 {name=x1109}
C {col_amp_2x1.sym} 7500 -540 0 0 {name=x1110}
C {col_amp_2x1.sym} 7840 -540 0 0 {name=x1111}
C {col_amp_2x1.sym} 8180 -540 0 0 {name=x1112}
C {col_amp_2x1.sym} 8520 -540 0 0 {name=x1113}
C {col_amp_2x1.sym} 8860 -540 0 0 {name=x1114}
C {col_amp_2x1.sym} 9200 -540 0 0 {name=x1115}
C {col_amp_2x1.sym} 9540 -540 0 0 {name=x1116}
C {col_amp_2x1.sym} 9880 -540 0 0 {name=x1117}
C {col_amp_2x1.sym} 10220 -540 0 0 {name=x1118}
C {col_amp_2x1.sym} 10560 -540 0 0 {name=x1119}
C {lab_wire.sym} -60 -660 0 0 {name=p10 sig_type=std_logic lab=GND}
C {lab_wire.sym} -60 -680 0 0 {name=p11 sig_type=std_logic lab=VDD}
C {lab_wire.sym} -60 -700 0 0 {name=p15 sig_type=std_logic lab=nCHARGE}
C {lab_wire.sym} -60 -720 0 0 {name=p16 sig_type=std_logic lab=VTHRESH}
C {lab_wire.sym} -60 -740 0 0 {name=p151 sig_type=std_logic lab=nDETECT}
C {lab_wire.sym} -60 -760 0 0 {name=p152 sig_type=std_logic lab=DETECT}
C {lab_wire.sym} 40 -950 3 0 {name=p153 sig_type=std_logic lab=pixRst[0]}
C {lab_wire.sym} 280 -950 3 0 {name=p154 sig_type=std_logic lab=pixRst[1]}
C {lab_wire.sym} 100 -950 3 0 {name=p155 sig_type=std_logic lab=voutn[0]}
C {lab_wire.sym} 220 -950 3 0 {name=p156 sig_type=std_logic lab=voutn[1]}
C {lab_wire.sym} 380 -950 3 0 {name=p157 sig_type=std_logic lab=pixRst[2]}
C {lab_wire.sym} 620 -950 3 0 {name=p158 sig_type=std_logic lab=pixRst[3]}
C {lab_wire.sym} 440 -950 3 0 {name=p159 sig_type=std_logic lab=voutn[2]}
C {lab_wire.sym} 560 -950 3 0 {name=p160 sig_type=std_logic lab=voutn[3]}
C {lab_wire.sym} 720 -950 3 0 {name=p161 sig_type=std_logic lab=pixRst[4]}
C {lab_wire.sym} 960 -950 3 0 {name=p162 sig_type=std_logic lab=pixRst[5]}
C {lab_wire.sym} 780 -950 3 0 {name=p163 sig_type=std_logic lab=voutn[4]}
C {lab_wire.sym} 900 -950 3 0 {name=p164 sig_type=std_logic lab=voutn[5]}
C {lab_wire.sym} 1060 -950 3 0 {name=p165 sig_type=std_logic lab=pixRst[6]}
C {lab_wire.sym} 1300 -950 3 0 {name=p166 sig_type=std_logic lab=pixRst[7]}
C {lab_wire.sym} 1120 -950 3 0 {name=p167 sig_type=std_logic lab=voutn[6]}
C {lab_wire.sym} 1240 -950 3 0 {name=p168 sig_type=std_logic lab=voutn[7]}
C {lab_wire.sym} 1400 -950 3 0 {name=p169 sig_type=std_logic lab=pixRst[8]}
C {lab_wire.sym} 1640 -950 3 0 {name=p170 sig_type=std_logic lab=pixRst[9]}
C {lab_wire.sym} 1460 -950 3 0 {name=p171 sig_type=std_logic lab=voutn[8]}
C {lab_wire.sym} 1580 -950 3 0 {name=p172 sig_type=std_logic lab=voutn[9]}
C {lab_wire.sym} 1740 -950 3 0 {name=p173 sig_type=std_logic lab=pixRst[10]}
C {lab_wire.sym} 1980 -950 3 0 {name=p174 sig_type=std_logic lab=pixRst[11]}
C {lab_wire.sym} 1800 -950 3 0 {name=p175 sig_type=std_logic lab=voutn[10]}
C {lab_wire.sym} 1920 -950 3 0 {name=p176 sig_type=std_logic lab=voutn[11]}
C {lab_wire.sym} 2080 -950 3 0 {name=p177 sig_type=std_logic lab=pixRst[12]}
C {lab_wire.sym} 2320 -950 3 0 {name=p178 sig_type=std_logic lab=pixRst[13]}
C {lab_wire.sym} 2140 -950 3 0 {name=p179 sig_type=std_logic lab=voutn[12]}
C {lab_wire.sym} 2260 -950 3 0 {name=p180 sig_type=std_logic lab=voutn[13]}
C {lab_wire.sym} 2420 -950 3 0 {name=p181 sig_type=std_logic lab=pixRst[14]}
C {lab_wire.sym} 2660 -950 3 0 {name=p182 sig_type=std_logic lab=pixRst[15]}
C {lab_wire.sym} 2480 -950 3 0 {name=p183 sig_type=std_logic lab=voutn[14]}
C {lab_wire.sym} 2600 -950 3 0 {name=p184 sig_type=std_logic lab=voutn[15]}
C {lab_wire.sym} 2760 -950 3 0 {name=p185 sig_type=std_logic lab=pixRst[16]}
C {lab_wire.sym} 3000 -950 3 0 {name=p186 sig_type=std_logic lab=pixRst[17]}
C {lab_wire.sym} 2820 -950 3 0 {name=p187 sig_type=std_logic lab=voutn[16]}
C {lab_wire.sym} 2940 -950 3 0 {name=p188 sig_type=std_logic lab=voutn[17]}
C {lab_wire.sym} 3100 -950 3 0 {name=p189 sig_type=std_logic lab=pixRst[18]}
C {lab_wire.sym} 3340 -950 3 0 {name=p190 sig_type=std_logic lab=pixRst[19]}
C {lab_wire.sym} 3160 -950 3 0 {name=p191 sig_type=std_logic lab=voutn[18]}
C {lab_wire.sym} 3280 -950 3 0 {name=p192 sig_type=std_logic lab=voutn[19]}
C {lab_wire.sym} 3440 -950 3 0 {name=p193 sig_type=std_logic lab=pixRst[20]}
C {lab_wire.sym} 3680 -950 3 0 {name=p194 sig_type=std_logic lab=pixRst[21]}
C {lab_wire.sym} 3500 -950 3 0 {name=p195 sig_type=std_logic lab=voutn[20]}
C {lab_wire.sym} 3620 -950 3 0 {name=p196 sig_type=std_logic lab=voutn[21]}
C {lab_wire.sym} 3780 -950 3 0 {name=p197 sig_type=std_logic lab=pixRst[22]}
C {lab_wire.sym} 4020 -950 3 0 {name=p198 sig_type=std_logic lab=pixRst[23]}
C {lab_wire.sym} 3840 -950 3 0 {name=p199 sig_type=std_logic lab=voutn[22]}
C {lab_wire.sym} 3960 -950 3 0 {name=p200 sig_type=std_logic lab=voutn[23]}
C {lab_wire.sym} 4120 -950 3 0 {name=p201 sig_type=std_logic lab=pixRst[24]}
C {lab_wire.sym} 4360 -950 3 0 {name=p202 sig_type=std_logic lab=pixRst[25]}
C {lab_wire.sym} 4180 -950 3 0 {name=p203 sig_type=std_logic lab=voutn[24]}
C {lab_wire.sym} 4300 -950 3 0 {name=p204 sig_type=std_logic lab=voutn[25]}
C {lab_wire.sym} 4460 -950 3 0 {name=p205 sig_type=std_logic lab=pixRst[26]}
C {lab_wire.sym} 4700 -950 3 0 {name=p206 sig_type=std_logic lab=pixRst[27]}
C {lab_wire.sym} 4520 -950 3 0 {name=p207 sig_type=std_logic lab=voutn[26]}
C {lab_wire.sym} 4640 -950 3 0 {name=p208 sig_type=std_logic lab=voutn[27]}
C {lab_wire.sym} 4800 -950 3 0 {name=p209 sig_type=std_logic lab=pixRst[28]}
C {lab_wire.sym} 5040 -950 3 0 {name=p210 sig_type=std_logic lab=pixRst[29]}
C {lab_wire.sym} 4860 -950 3 0 {name=p211 sig_type=std_logic lab=voutn[28]}
C {lab_wire.sym} 4980 -950 3 0 {name=p212 sig_type=std_logic lab=voutn[29]}
C {lab_wire.sym} 5140 -950 3 0 {name=p213 sig_type=std_logic lab=pixRst[30]}
C {lab_wire.sym} 5380 -950 3 0 {name=p214 sig_type=std_logic lab=pixRst[31]}
C {lab_wire.sym} 5200 -950 3 0 {name=p215 sig_type=std_logic lab=voutn[30]}
C {lab_wire.sym} 5320 -950 3 0 {name=p216 sig_type=std_logic lab=voutn[31]}
C {lab_wire.sym} 5480 -950 3 0 {name=p217 sig_type=std_logic lab=pixRst[32]}
C {lab_wire.sym} 5720 -950 3 0 {name=p218 sig_type=std_logic lab=pixRst[33]}
C {lab_wire.sym} 5540 -950 3 0 {name=p219 sig_type=std_logic lab=voutn[32]}
C {lab_wire.sym} 5660 -950 3 0 {name=p220 sig_type=std_logic lab=voutn[33]}
C {lab_wire.sym} 5820 -950 3 0 {name=p221 sig_type=std_logic lab=pixRst[34]}
C {lab_wire.sym} 6060 -950 3 0 {name=p222 sig_type=std_logic lab=pixRst[35]}
C {lab_wire.sym} 5880 -950 3 0 {name=p223 sig_type=std_logic lab=voutn[34]}
C {lab_wire.sym} 6000 -950 3 0 {name=p224 sig_type=std_logic lab=voutn[35]}
C {lab_wire.sym} 6160 -950 3 0 {name=p225 sig_type=std_logic lab=pixRst[36]}
C {lab_wire.sym} 6400 -950 3 0 {name=p226 sig_type=std_logic lab=pixRst[37]}
C {lab_wire.sym} 6220 -950 3 0 {name=p227 sig_type=std_logic lab=voutn[36]}
C {lab_wire.sym} 6340 -950 3 0 {name=p228 sig_type=std_logic lab=voutn[37]}
C {lab_wire.sym} 6500 -950 3 0 {name=p229 sig_type=std_logic lab=pixRst[38]}
C {lab_wire.sym} 6740 -950 3 0 {name=p230 sig_type=std_logic lab=pixRst[39]}
C {lab_wire.sym} 6560 -950 3 0 {name=p231 sig_type=std_logic lab=voutn[38]}
C {lab_wire.sym} 6680 -950 3 0 {name=p232 sig_type=std_logic lab=voutn[39]}
C {lab_wire.sym} 6840 -950 3 0 {name=p233 sig_type=std_logic lab=pixRst[40]}
C {lab_wire.sym} 7080 -950 3 0 {name=p234 sig_type=std_logic lab=pixRst[41]}
C {lab_wire.sym} 6900 -950 3 0 {name=p235 sig_type=std_logic lab=voutn[40]}
C {lab_wire.sym} 7020 -950 3 0 {name=p236 sig_type=std_logic lab=voutn[41]}
C {lab_wire.sym} 7180 -950 3 0 {name=p237 sig_type=std_logic lab=pixRst[42]}
C {lab_wire.sym} 7420 -950 3 0 {name=p238 sig_type=std_logic lab=pixRst[43]}
C {lab_wire.sym} 7240 -950 3 0 {name=p239 sig_type=std_logic lab=voutn[42]}
C {lab_wire.sym} 7360 -950 3 0 {name=p240 sig_type=std_logic lab=voutn[43]}
C {lab_wire.sym} 7520 -950 3 0 {name=p241 sig_type=std_logic lab=pixRst[44]}
C {lab_wire.sym} 7760 -950 3 0 {name=p242 sig_type=std_logic lab=pixRst[45]}
C {lab_wire.sym} 7580 -950 3 0 {name=p243 sig_type=std_logic lab=voutn[44]}
C {lab_wire.sym} 7700 -950 3 0 {name=p244 sig_type=std_logic lab=voutn[45]}
C {lab_wire.sym} 7860 -950 3 0 {name=p245 sig_type=std_logic lab=pixRst[46]}
C {lab_wire.sym} 8100 -950 3 0 {name=p246 sig_type=std_logic lab=pixRst[47]}
C {lab_wire.sym} 7920 -950 3 0 {name=p247 sig_type=std_logic lab=voutn[46]}
C {lab_wire.sym} 8040 -950 3 0 {name=p248 sig_type=std_logic lab=voutn[47]}
C {lab_wire.sym} 8200 -950 3 0 {name=p249 sig_type=std_logic lab=pixRst[48]}
C {lab_wire.sym} 8440 -950 3 0 {name=p250 sig_type=std_logic lab=pixRst[49]}
C {lab_wire.sym} 8260 -950 3 0 {name=p251 sig_type=std_logic lab=voutn[48]}
C {lab_wire.sym} 8380 -950 3 0 {name=p252 sig_type=std_logic lab=voutn[49]}
C {lab_wire.sym} 8540 -950 3 0 {name=p253 sig_type=std_logic lab=pixRst[50]}
C {lab_wire.sym} 8780 -950 3 0 {name=p254 sig_type=std_logic lab=pixRst[51]}
C {lab_wire.sym} 8600 -950 3 0 {name=p255 sig_type=std_logic lab=voutn[50]}
C {lab_wire.sym} 8720 -950 3 0 {name=p256 sig_type=std_logic lab=voutn[51]}
C {lab_wire.sym} 8880 -950 3 0 {name=p257 sig_type=std_logic lab=pixRst[52]}
C {lab_wire.sym} 9120 -950 3 0 {name=p258 sig_type=std_logic lab=pixRst[53]}
C {lab_wire.sym} 8940 -950 3 0 {name=p259 sig_type=std_logic lab=voutn[52]}
C {lab_wire.sym} 9060 -950 3 0 {name=p260 sig_type=std_logic lab=voutn[53]}
C {lab_wire.sym} 9220 -950 3 0 {name=p261 sig_type=std_logic lab=pixRst[54]}
C {lab_wire.sym} 9460 -950 3 0 {name=p262 sig_type=std_logic lab=pixRst[55]}
C {lab_wire.sym} 9280 -950 3 0 {name=p263 sig_type=std_logic lab=voutn[54]}
C {lab_wire.sym} 9400 -950 3 0 {name=p264 sig_type=std_logic lab=voutn[55]}
C {lab_wire.sym} 9560 -950 3 0 {name=p265 sig_type=std_logic lab=pixRst[56]}
C {lab_wire.sym} 9800 -950 3 0 {name=p266 sig_type=std_logic lab=pixRst[57]}
C {lab_wire.sym} 9620 -950 3 0 {name=p267 sig_type=std_logic lab=voutn[56]}
C {lab_wire.sym} 9740 -950 3 0 {name=p268 sig_type=std_logic lab=voutn[57]}
C {lab_wire.sym} 9900 -950 3 0 {name=p269 sig_type=std_logic lab=pixRst[58]}
C {lab_wire.sym} 10140 -950 3 0 {name=p270 sig_type=std_logic lab=pixRst[59]}
C {lab_wire.sym} 9960 -950 3 0 {name=p271 sig_type=std_logic lab=voutn[58]}
C {lab_wire.sym} 10080 -950 3 0 {name=p272 sig_type=std_logic lab=voutn[59]}
C {lab_wire.sym} 10240 -950 3 0 {name=p273 sig_type=std_logic lab=pixRst[60]}
C {lab_wire.sym} 10480 -950 3 0 {name=p274 sig_type=std_logic lab=pixRst[61]}
C {lab_wire.sym} 10300 -950 3 0 {name=p275 sig_type=std_logic lab=voutn[60]}
C {lab_wire.sym} 10420 -950 3 0 {name=p276 sig_type=std_logic lab=voutn[61]}
C {lab_wire.sym} 10580 -950 3 0 {name=p277 sig_type=std_logic lab=pixRst[62]}
C {lab_wire.sym} 10820 -950 3 0 {name=p278 sig_type=std_logic lab=pixRst[63]}
C {lab_wire.sym} 10640 -950 3 0 {name=p279 sig_type=std_logic lab=voutn[62]}
C {lab_wire.sym} 10760 -950 3 0 {name=p280 sig_type=std_logic lab=voutn[63]}
C {iopin.sym} -500 -570 3 0 {name=p14 lab=nCHARGE}
C {iopin.sym} -470 -570 3 0 {name=p281 lab=VTHRESH}
C {iopin.sym} -500 -460 3 0 {name=p282 lab=nDETECT}
C {iopin.sym} -470 -460 3 0 {name=p283 lab=DETECT}
C {iopin.sym} -380 -460 3 0 {name=p284 lab=rowReadON[63:0]}
C {iopin.sym} -360 -460 3 0 {name=p285 lab=rowReadOFF[63:0]}
C {iopin.sym} -340 -460 3 0 {name=p286 lab=pixRst[63:0]}
C {iopin.sym} -320 -460 3 0 {name=p287 lab=voutn[63:0]}
